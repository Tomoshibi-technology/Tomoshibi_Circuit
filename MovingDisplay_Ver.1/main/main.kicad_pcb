# Repository Tomoshibi-technology/Tomoshibi_Circuit (continued)

## KiCad design projects/MovingDisplay_Ver.1/motordriver/motordriver.kicad_pcb

Board: 2 copper layers, 125.0 x 70.0 mm, 131 parts (45 on the bottom side), 73 nets.

Parts:
C1, C4, C7, C9, C10, C18, C19, C22, C23, C24: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C16, C17: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C13: 470uF; C_Elec_8x10.2
C6: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8, C11, C14, C15: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C12: ADJ_ST; C_Disc_D5.0mm_W2.5mm_P5.00mm
C20, C21: C; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
D1, D4, D6, D11, D12, D13, D14, D15, D16: D; D_SOD-123
D2, D3, D5, D7, D8, D9, D10: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J4: Conn_01x02_Female; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2: Conn_01x10_Female; IDC-Header_2x05_P2.54mm_Horizontal
J3, J5: Conn_01x05_Female; Molex_PicoBlade_53261-0571_1x05-1MP_P1.25mm_Horizontal
JP1: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
Q1, Q3: Q_PMOS_GDS; TO-252-3_TabPin2
Q2, Q9, Q10: Q_NMOS_GSD; SOT-23_Handsoldering
Q4, Q7, Q16: Q_PNP_BEC; SC-59_Handsoldering
Q5, Q6, Q8, Q15: PMN48XP; SSM6J808R
Q11, Q12, Q13, Q14: FDMS8050; TPN1R603PLL1Q
R1, R2, R3, R5, R6, R8, R13, R14, R15, R16, R17, R18, R20, R21, R22, R23, R24, R26, R27, R32, R35, R36, R45, R46, R47, R48, R49: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R11, R12, R19, R25, R28, R29, R30, R31, R39, R40: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R10, R41, R42, R43, R44, R55: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R33, R34, R37, R38: 510; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R50: 7.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R51: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R52, R53: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R54: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW8: SW_SPST; SW_SPST_Omron_B3FS-100xP
SW2, SW3, SW7, SW9: SW_SPDT; 3P_SPDT_SlideSwitch
SW5: SW_DIP_x04; DIP-8_W7.62mm
SW6: SW_SPDT; 3P_SPDT_5Pin_ToggleSwitch
U1: LF50_TO220; BP5293
U2: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
U3: AMS1117CD-3.3; TO-252-3_TabPin2
U4, U5: TLP785; DIP-4_W7.62mm
U6, U7: IR2302; SOP-8_3.9x4.9mm_P1.27mm
U8: MAX3485; SOP-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C1.1, C7.1, C10.1, C11.1, C15.1, C22.1, C24.1, D6.2 (A), J2.2, J5.2, Q16.2 (E), R18.1, R32.2, R37.1, R38.1, R52.1, SW1.2 (B), SW2.2 (B), SW3.2 (B), SW5.5, SW5.6, SW5.7, SW5.8, SW7.2 (B), U2.1 (VDD), U2.5 (VDDA), U2.17 (VDD), U3.2 (VO), U8.8 (VCC)
+5V: C13.1, C14.1, D6.1 (K), Q6.4 (S), Q7.2 (E), Q8.4 (S), R27.2, R31.2, R39.2, R40.2, U3.3 (VI)
+7.5V: J1.2, Q1.2 (D)
/S-S: C3.1, D1.1 (K), Q1.3 (S), Q3.3 (S), R5.1, R6.1, SW6.2 (B)
/VSYS: C8.1, D4.2 (A), Q4.2 (E), Q6.1 (D), Q6.2 (D), Q6.5 (D), Q6.6 (D), R21.2, R24.1, R25.2, R28.2, U1.3 (VO)
BOOT0: R19.2, R20.1, SW7.1 (A), U2.31 (BOOT0)
DIPSW1: R8.2, SW5.1, U2.14 (PB0)
DIPSW2: R13.2, SW5.2, U2.13 (PA7)
DIPSW3: R15.2, SW5.3, U2.12 (PA6)
DIPSW4: R16.2, SW5.4, U2.11 (PA5)
Encoder_OUT: J5.5, U2.9 (PA3)
GND: C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.1, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C22.2, C23.2, C24.2, D1.2 (A), D2.1 (K), D3.1 (K), D5.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D14.2 (A), D16.2 (A), J1.1, J2.4, J3.1, J5.1, Q1.1 (G), Q2.2 (S), Q9.2 (S), Q10.2 (S), Q12.1 (S), Q12.2 (S), Q12.3 (S), Q14.1 (S), Q14.2 (S), Q14.3 (S), R1.1, R2.2, R3.2, R5.2, R8.1, R10.2, R13.1, R14.2, R15.1, R16.1, R17.1, R20.2, R21.1, R22.1, R23.1, R25.1, R26.1, R27.1, R32.1, R35.1, R36.1, R46.1, R48.1, R51.2, R53.2, SW8.2 (B), SW9.2 (B), U1.2 (GND), U2.16 (VSS), U2.32 (VSS), U3.1 (GND), U4.2, U4.3, U5.2, U5.3, U6.4 (COM), U7.4 (COM), U8.5 (GND)
I2C1_SCL: J5.3, U2.29 (PB6)
I2C1_SDA: J5.4, U2.30 (PB7)
IndicatorLED: Q5.1 (D), Q5.2 (D), Q5.5 (D), Q5.6 (D), Q8.1 (D), Q8.2 (D), Q8.5 (D), Q8.6 (D), R30.2
LED1: R11.2, U2.15 (PB1)
LED2: R12.2, U2.22 (PA12)
MD_GPIO: J3.3, U2.10 (PA4)
MD_Pw: C23.1, J3.2, Q15.1 (D), Q15.2 (D), Q15.5 (D), Q15.6 (D)
MainRX1_MAX3485TX: U2.20 (PA10), U8.1 (RO)
MainRX2_STLinkTX: J2.8, U2.25 (PA15)
MainTX1_MAX3485RX: R50.2, U2.19 (PA9), U8.4 (DI)
MainTX2_STLinkRX: J2.9, U2.8 (PA2)
Motor_A: C20.2, D13.2 (A), D14.1 (K), J4.1, Q11.1 (S), Q11.2 (S), Q11.3 (S), Q12.5 (D), R45.1, U6.6 (VS)
Motor_B: C21.2, D15.2 (A), D16.1 (K), J4.2, Q13.1 (S), Q13.2 (S), Q13.3 (S), Q14.5 (D), R47.1, U7.6 (VS)
NRST: C9.1, J2.6, R18.2, SW8.1 (A), U2.4 (NRST)
unnamed: C3.2, Q3.1 (G), R6.2, R7.1
unnamed: C12.2, Q5.3 (G), Q8.3 (G), R24.2
unnamed: C20.1, D11.1 (K), U6.8 (VB)
unnamed: C21.1, D12.1 (K), U7.8 (VB)
unnamed: D2.2 (A), R11.1
unnamed: D3.2 (A), R12.1
unnamed: D5.2 (A), R19.1
unnamed: D7.2 (A), R28.1
unnamed: D8.2 (A), R29.1
unnamed: D9.2 (A), R30.1
unnamed: D10.2 (A), R31.1
unnamed: JP1.2 (B), R54.1
unnamed: Q2.3 (D), R7.2
unnamed: Q4.1 (B), Q4.3 (C), Q7.1 (B), R22.2
unnamed: Q6.3 (G), Q7.3 (C), R26.2
unnamed: Q9.1 (G), R33.2, R35.2
unnamed: Q9.3 (D), R37.2, U4.1
unnamed: Q10.1 (G), R34.2, R36.2
unnamed: Q10.3 (D), R38.2, U5.1
unnamed: Q11.4 (G), R41.2, R45.2
unnamed: Q12.4 (G), R42.2, R46.2
unnamed: Q13.4 (G), R43.2, R47.2
unnamed: Q14.4 (G), R44.2, R48.2
unnamed: Q15.3 (G), R49.2, SW9.1 (A)
unnamed: Q16.1 (B), R50.1
unnamed: Q16.3 (C), R51.1, U8.2 (~RE), U8.3 (DE)
unnamed: R39.1, U4.4, U6.2 (IN)
unnamed: R40.1, U5.4, U7.2 (IN)
unnamed: R41.1, U6.7 (HO)
unnamed: R42.1, U6.5 (LO)
unnamed: R43.1, U7.7 (HO)
unnamed: R44.1, U7.5 (LO)
unnamed: R55.1, U2.6 (PA0)
PWM_A: R33.1, U2.21 (PA11)
PWM_B: R34.1, U2.18 (PA8)
RS485_MD_A: J3.4, JP1.1 (A), R52.2, U8.6 (A)
RS485_MD_B: J3.5, R53.1, R54.2, U8.7 (B)
Slide_Switch1: R2.1, SW2.1 (A), U2.26 (PB3)
Slide_Switch2: R3.1, SW3.1 (A), U2.27 (PB4)
TCK: J2.3, U2.24 (PA14)
TMS: J2.5, U2.23 (PA13)
Tact_Switch1: C1.2, R1.2, SW1.1 (A), U2.28 (PB5)
VBUS: C4.1, J2.1, Q5.4 (S), Q15.4 (S), R23.2, R29.2, R49.1
VDD: C5.1, C6.1, C16.1, C17.1, C18.1, C19.1, D4.1 (K), D11.2 (A), D12.2 (A), D13.1 (K), D15.1 (K), Q3.2 (D), Q11.5 (D), Q13.5 (D), R9.1, R17.2, U1.1 (VI), U6.1 (VCC), U7.1 (VCC)
V_Measure: R9.2, R10.1, U2.7 (PA1)
shutdown: R55.2, U6.3 (~SD), U7.3 (~SD)
主電源スイッチ: Q2.1 (G), R14.1, SW6.1 (A)

## KiCad design projects/MovingDisplay_Ver.2/MD/MD.kicad_pcb

Board: 2 copper layers, 147.0 x 57.0 mm, 132 parts (4 on the bottom side), 68 nets.

Parts:
C1, C7, C8, C9, C20, C21, C26, C29: 0.1uF; C_0402_1005Metric
C2, C17, C18: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C5, C13, C16, C30, C31, C32: 470uF; C_Elec_8x10.2
C6: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C10, C11, C14, C15, C28: 1uF; C_0402_1005Metric
C23, C24: C; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
D1, D5, D7: D; D_SOD-123
D2: D_Schottky; DO-221BC
D3, D4, D6, D11, D21, D22: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D12, D13, D15, D16, D17, D18: D_Schottky; D_SOD-123
H4, H5, H6, H7, H8, H9: MountingHole; MountingHole_3.2mm_M3
J1, J4: Conn_01x02_Female; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2: Conn_01x10_Female; IDC-Header_2x05_P2.54mm_Horizontal
J3, J5: Conn_01x05_Female; Molex_SPOX_5268-05A_1x05_P2.50mm_Horizontal
JP1: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
Q1, Q3: Q_PMOS_GDS; TO-252-3_TabPin2
Q2, Q9, Q10: Q_NMOS_GSD; SOT-23_Handsoldering
Q13: Q_PNP_BEC; SC-59_Handsoldering
Q14, Q15, Q16, Q17: FDMS8050; SOP-Advance
R1, R2, R3, R4, R5, R7, R10, R11, R12, R13, R14, R15, R17, R18, R30, R34, R35, R50, R51, R52, R53, R62: 10k; R_0402_1005Metric
R6, R8, R9, R16, R29, R40, R41: 1k; R_0402_1005Metric
R25, R44, R45, R46, R47, R63, R64, R65, R66: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R31, R32, R37, R38: 510; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R56: 7.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R57: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R58, R59: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R60: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R61: MPR; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
SW1, SW2, SW6: SW_SPDT; 3P_SPDT_SlideSwitch
SW3, SW7: SW_SPST; SW_SPST_Omron_B3FS-100xP
SW4: SW_DIP_x04; DIP-8_W7.62mm
SW5: SW_SPDT; 3P_SPDT_5Pin_ToggleSwitch
TP1, TP2, TP3, TP4, TP5: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: LF50_TO220; BP5293
U2: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
U3: AMS1117CD-3.3; TO-252-3_TabPin2
U4, U5: TLP785; DIP-4_W7.62mm
U7, U8: IR2302; SOP-8_3.9x4.9mm_P1.27mm
U10: MAX3485; SOP-8_3.9x4.9mm_P1.27mm

Connections:
4PSW1: R7.2, SW4.1, U2.13 (PA7)
4PSW2: R10.2, SW4.2, U2.14 (PB0)
4PSW3: R11.2, SW4.3, U2.15 (PB1)
4PSW4: R12.2, SW4.4, U2.28 (PB5)
+3.3V: C1.1, C7.1, C9.1, C11.1, C15.1, C26.1, C29.1, D7.2 (A), J5.2, Q13.2 (E), R15.1, R30.2, R37.1, R38.1, R58.1, R66.1, SW1.2 (B), SW2.2 (B), SW3.2 (B), SW4.5, SW4.6, SW4.7, SW4.8, SW6.2 (B), TP4.1, U2.1 (VDD), U2.5 (VDDA), U2.17 (VDD), U3.2 (VO), U10.8 (VCC)
+5V: C10.1, C14.1, D5.2 (A), D7.1 (K), R18.2, R29.2, R40.2, R41.2, R65.1, TP3.1, U1.3 (VO), U3.3 (VI)
+12V: J1.2, Q1.2 (D)
/S-S: C2.1, D1.1 (K), Q1.3 (S), Q3.3 (S), R4.1, R5.1, SW5.2 (B)
BOOT0: R16.2, R17.1, SW6.1 (A), U2.31 (BOOT0)
Encoder_OUT: J5.5, U2.9 (PA3)
GND: C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C20.2, C21.2, C26.2, C29.2, C30.2, C31.2, C32.2, D1.2 (A), D3.1 (K), D4.1 (K), D6.1 (K), D11.1 (K), D16.2 (A), D18.2 (A), J1.1, J2.4, J3.1, J5.1, Q1.1 (G), Q2.2 (S), Q9.2 (S), Q10.2 (S), Q15.1 (S), Q15.2 (S), Q15.3 (S), Q17.1 (S), Q17.2 (S), Q17.3 (S), R1.1, R2.2, R3.2, R4.2, R7.1, R10.1, R11.1, R12.1, R13.2, R14.1, R17.2, R18.1, R30.1, R34.1, R35.1, R51.1, R53.1, R57.2, R59.2, SW7.2 (B), TP5.1, U1.2 (GND), U2.16 (VSS), U2.32 (VSS), U3.1 (GND), U4.2, U4.3, U5.2, U5.3, U7.4 (COM), U8.4 (COM), U10.5 (GND)
I2C1_SCL: J5.3, U2.29 (PB6)
I2C1_SDA: J5.4, U2.30 (PB7)
LED1: R8.2, U2.7 (PA1)
LED2: R9.2, U2.6 (PA0)
MD_GPIO: J3.3, U2.21 (PA11)
MainRX1_MAX3485TX: U2.20 (PA10), U10.1 (RO)
MainRX2_STLinkTX: J2.8, U2.25 (PA15)
MainTX1_MAX3485RX: R56.2, U2.19 (PA9), U10.4 (DI)
MainTX2_STLinkRX: J2.9, U2.8 (PA2)
Motor_A: C23.2, D15.2 (A), D16.1 (K), J4.1, Q14.1 (S), Q14.2 (S), Q14.3 (S), Q15.5 (D), R50.1, R61.1, R62.2, U7.6 (VS)
Motor_B: C24.2, C28.2, D17.2 (A), D18.1 (K), D21.1 (K), D22.2 (A), J4.2, Q16.1 (S), Q16.2 (S), Q16.3 (S), Q17.5 (D), R52.1, U8.6 (VS)
NRST: C8.1, J2.6, R15.2, SW7.1 (A), U2.4 (NRST)
unnamed: C2.2, Q3.1 (G), R5.2, R6.1
unnamed: C4.1, R63.2
unnamed: C5.1, C13.1, C16.1, C30.1, R64.2
unnamed: C23.1, D12.1 (K), U7.8 (VB)
unnamed: C24.1, D13.1 (K), U8.8 (VB)
unnamed: C28.1, R61.2
unnamed: C31.1, R65.2
unnamed: C32.1, R66.2
unnamed: D3.2 (A), R8.1
unnamed: D4.2 (A), R9.1
unnamed: D6.2 (A), R16.1
unnamed: D11.2 (A), R29.1
unnamed: D21.2 (A), D22.1 (K), R62.1
unnamed: JP1.2 (B), R60.1
unnamed: Q2.3 (D), R6.2
unnamed: Q9.1 (G), R31.2, R34.2
unnamed: Q9.3 (D), R37.2, U4.1
unnamed: Q10.1 (G), R32.2, R35.2
unnamed: Q10.3 (D), R38.2, U5.1
unnamed: Q13.1 (B), R56.1
unnamed: Q13.3 (C), R57.1, U10.2 (~RE), U10.3 (DE)
unnamed: Q14.4 (G), R44.2, R50.2
unnamed: Q15.4 (G), R45.2, R51.2
unnamed: Q16.4 (G), R46.2, R52.2
unnamed: Q17.4 (G), R47.2, R53.2
unnamed: R25.1, U2.26 (PB3)
unnamed: R40.1, U4.4, U7.2 (IN)
unnamed: R41.1, U5.4, U8.2 (IN)
unnamed: R44.1, U7.7 (HO)
unnamed: R45.1, U7.5 (LO)
unnamed: R46.1, U8.7 (HO)
unnamed: R47.1, U8.5 (LO)
PWM_A: R31.1, U2.18 (PA8)
PWM_B: R32.1, U2.22 (PA12)
RS485_MD_A: J3.4, JP1.1 (A), R58.2, U10.6 (A)
RS485_MD_B: J3.5, R59.1, R60.2, U10.7 (B)
Slide_Switch1: R2.1, SW1.1 (A), U2.11 (PA5)
Slide_Switch2: R3.1, SW2.1 (A), U2.12 (PA6)
TCK: J2.3, U2.24 (PA14)
TMS: J2.5, U2.23 (PA13)
Tact_Switch1: C1.2, R1.2, SW3.1 (A), U2.27 (PB4)
VCC: C6.1, C20.1, C21.1, D2.1 (K), D5.1 (K), D12.2 (A), D13.2 (A), R14.2, R64.1, TP2.1, U1.1 (VI), U7.1 (VCC), U8.1 (VCC)
VDD: C17.1, C18.1, D2.2 (A), D15.1 (K), D17.1 (K), Q3.2 (D), Q14.5 (D), Q16.5 (D), R63.1, TP1.1
shutdown: R25.2, U7.3 (~SD), U8.3 (~SD)
主電源スイッチ: Q2.1 (G), R13.1, SW5.1 (A)

File projects/MovingDisplay_Ver.2/MD/jlcpcb/production_files/BOM-MD.csv:

Comment,Designator,Footprint,LCSC
Q_NMOS_GSD,"Q10,Q2,Q9",SOT-23_Handsoldering,C112239
1k,"R16,R29,R40,R41,R6,R8,R9",R_0402_1005Metric,C11702
FDMS8050,"Q14,Q15,Q16,Q17",SOP-Advance,C141553
10k,"R1,R10,R11,R12,R13,R14,R15,R17,R18,R2,R3,R30,R34,R35,R4,R5,R50,R51,R52,R53,R62,R7",R_0402_1005Metric,C25744
0.1uF,"C1,C20,C21,C26,C29,C7,C8,C9",C_0402_1005Metric,C307331
1uF,"C10,C11,C14,C15,C28",C_0402_1005Metric,C52923
MAX3485,U10,SOP-8_3.9x4.9mm_P1.27mm,C558792
MountingHole,H8,MountingHole_3.2mm_M3,
STM32F303K8Tx,U2,LQFP-32_7x7mm_P0.8mm,
470uF,C32,C_Elec_8x10.2,
D_Schottky,D15,D_SOD-123,
TestPoint,TP2,TestPoint_THTPad_D2.0mm_Drill1.0mm,
MountingHole,H9,MountingHole_3.2mm_M3,
470uF,C13,C_Elec_8x10.2,
510,R37,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
C,C24,C_1210_3225Metric_Pad1.33x2.70mm_HandSolder,
R,R47,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
D_Schottky,D18,D_SOD-123,
SW_SPST,SW3,SW_SPST_Omron_B3FS-100xP,
SW_DIP_x04,SW4,DIP-8_W7.62mm,
Conn_01x05_Female,J3,Molex_SPOX_5268-05A_1x05_P2.50mm_Horizontal,
LED,D3,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
TestPoint,TP5,TestPoint_THTPad_D2.0mm_Drill1.0mm,
Conn_01x10_Female,J2,IDC-Header_2x05_P2.54mm_Horizontal,
Q_PMOS_GDS,Q1,TO-252-3_TabPin2,
7.5k,R56,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
TestPoint,TP1,TestPoint_THTPad_D2.0mm_Drill1.0mm,
470uF,C16,C_Elec_8x10.2,
4.7uF,C2,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
LED,D6,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
LED,D22,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
SW_SPST,SW7,SW_SPST_Omron_B3FS-100xP,
Conn_01x02_Female,J4,AMASS_XT30PW-M_1x02_P2.50mm_Horizontal,
C,C23,C_1210_3225Metric_Pad1.33x2.70mm_HandSolder,
SW_SPDT,SW6,3P_SPDT_SlideSwitch,
510,R31,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
IR2302,U8,SOP-8_3.9x4.9mm_P1.27mm,
R,R63,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
LED,D21,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
R,R65,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
Conn_01x02_Female,J1,AMASS_XT30PW-M_1x02_P2.50mm_Horizontal,
MountingHole,H7,MountingHole_3.2mm_M3,
D,D1,D_SOD-123,
MountingHole,H5,MountingHole_3.2mm_M3,
510,R38,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
510,R32,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
R,R46,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
D_Schottky,D13,D_SOD-123,
Jumper_2_Open,JP1,PinHeader_1x02_P2.54mm_Vertical,
AMS1117CD-3.3,U3,TO-252-3_TabPin2,
2.2k,R58,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
4.7uF,C18,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
120,R60,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
Conn_01x05_Female,J5,Molex_SPOX_5268-05A_1x05_P2.50mm_Horizontal,
D_Schottky,D16,D_SOD-123,
R,R45,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
Q_PMOS_GDS,Q3,TO-252-3_TabPin2,
D_Schottky,D12,D_SOD-123,
R,R66,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
LED,D4,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
TestPoint,TP3,TestPoint_THTPad_D2.0mm_Drill1.0mm,
LED,D11,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
20k,R57,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
IR2302,U7,SOP-8_3.9x4.9mm_P1.27mm,
2.2k,R59,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
470uF,C5,C_Elec_8x10.2,
470uF,C30,C_Elec_8x10.2,
D_Schottky,D2,DO-221BC,
SW_SPDT,SW5,3P_SPDT_5Pin_ToggleSwitch,
TestPoint,TP4,TestPoint_THTPad_D2.0mm_Drill1.0mm,
470uF,C4,C_Elec_8x10.2,
D,D7,D_SOD-123,
R,R44,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
LF50_TO220,U1,BP5293,
TLP785,U4,DIP-4_W7.62mm,
4.7uF,C17,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
470uF,C31,C_Elec_8x10.2,
Q_PNP_BEC,Q13,SC-59_Handsoldering,
MountingHole,H6,MountingHole_3.2mm_M3,
SW_SPDT,SW1,3P_SPDT_SlideSwitch,
TLP785,U5,DIP-4_W7.62mm,
MountingHole,H4,MountingHole_3.2mm_M3,
MPR,R61,R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal,
SW_SPDT,SW2,3P_SPDT_SlideSwitch,
D_Schottky,D17,D_SOD-123,
R,R64,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
D,D5,D_SOD-123,
R,R25,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,
10uF,C6,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,

## KiCad design projects/MovingDisplay_Ver.2/Odometry/Odometry.kicad_pcb

Parts:
C2: 4.7uF; C_0603_1608Metric
C4, C14, C16, C18, C19: 0.1uF; C_0402_1005Metric
C6, C12: 470uF; C_Elec_8x10.2
C7: 10uF; C_0805_2012Metric
C10, C17: 1uF; C_0402_1005Metric
C13: ADJ_ST; C_Disc_D5.0mm_W2.5mm_P5.00mm
D2: D_Schottky; D_SOD-123
D3, D4, D5: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D6: D; D_SOD-123
D8, D9, D10, D11: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J2: Conn_01x02_Female; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J3: Conn_01x10_Female; IDC-Header_2x05_P2.54mm_Horizontal
J4, J5, J6: Conn_01x05_Female; Molex_SPOX_5268-05A_1x05_P2.50mm_Horizontal
JP1: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
Q1, Q3: SSM6J808R
Q2: Q_NMOS_GSD; SOT-23
Q4, Q7, Q9: Q_PNP_BEC; SC-59_Handsoldering
Q5, Q6, Q8: Q_PMOS_GSD; SOT-23
R1, R2, R3, R4, R5, R6, R8, R12, R14, R15, R17, R19, R20, R21, R23, R24, R25, R27: 10k; R_0402_1005Metric
R7, R9, R10, R11, R22, R28, R29, R30, R31: 1k; R_0402_1005Metric
R32: 7.5k; R_0603_1608Metric
R33: 20k; R_0402_1005Metric
R34, R35: 2.2k; R_0402_1005Metric
R36: 120; R_0402_1005Metric
SW1, SW4, SW7, SW8: SW_SPST; SW_SPST_Omron_B3FS-100xP
SW2, SW3: SW_SPDT; 3P_SPDT_SlideSwitch
SW5: SW_SPDT; 3P_SPDT_5Pin_ToggleSwitch
SW6: SW_DIP_x02; DIP-4_W7.62mm
U1: BP5293-33; BP5293
U2: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
U3: MAX3485; SOP-8_3.9x4.9mm_P1.27mm

Connections:
2PSW1: R12.2, SW6.1, U2.13 (PA7)
2PSW2: R14.2, SW6.2, U2.14 (PB0)
+3.3V: C12.1, C14.1, C16.1, C17.1, C18.1, C19.1, J4.2, Q6.2 (S), Q7.2 (E), Q8.2 (S), Q9.2 (E), R24.2, R25.1, R31.2, R34.1, SW1.2 (B), SW2.2 (B), SW3.2 (B), SW4.2 (B), SW6.3, SW6.4, SW7.2 (B), U2.1 (VDD), U2.5 (VDDA), U2.17 (VDD), U3.8 (VCC)
+12V: J1.2, J2.2, Q1.1 (D), Q1.2 (D), Q1.5 (D), Q1.6 (D)
/S-S: C2.1, Q1.4 (S), Q3.4 (S), R2.1, R6.1, SW5.2 (B)
/VSYS: C10.1, D6.2 (A), Q4.2 (E), Q6.3 (D), R17.2, R21.1, R22.2, R28.2, U1.3 (VO)
BOOT0: R27.1, SW7.1 (A), U2.31 (BOOT0)
Encoder_OUT: J4.5, U2.9 (PA3)
GND: C4.2, C6.2, C7.2, C10.2, C12.2, C13.1, C14.2, C16.2, C17.2, C18.2, C19.2, D3.1 (K), D4.1 (K), D5.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), J1.1, J2.1, J3.4, J4.1, J5.1, J6.1, Q1.3 (G), Q2.2 (S), R1.1, R2.2, R3.2, R4.2, R5.1, R8.2, R12.1, R14.1, R15.1, R17.1, R19.1, R20.1, R22.1, R23.1, R24.1, R27.2, R33.2, R35.2, SW8.2 (B), U1.2 (GND), U2.16 (VSS), U2.32 (VSS), U3.5 (GND)
I2C1_SCL: J4.3, U2.29 (PB6)
I2C1_SDA: J4.4, U2.30 (PB7)
IndicatorLED: Q5.3 (D), Q8.3 (D), R30.2
LED1: R9.2, U2.7 (PA1)
LED2: R10.2, U2.11 (PA5)
LED3: R11.2, U2.12 (PA6)
MainRX1_MAX3485TX: U2.20 (PA10), U3.1 (RO)
MainRX2_STLinkTX: J3.8, U2.25 (PA15)
MainTX1_MAX3485RX: R32.2, U2.19 (PA9), U3.4 (DI)
MainTX2_STLinkRX: J3.9, U2.8 (PA2)
NRST: J3.6, R25.2, SW8.1 (A), U2.4 (NRST)
unnamed: C2.2, Q3.3 (G), R6.2, R7.1
unnamed: C13.2, Q5.1 (G), Q8.1 (G), R21.2
unnamed: D3.2 (A), R9.1
unnamed: D4.2 (A), R10.1
unnamed: D5.2 (A), R11.1
unnamed: D8.2 (A), R28.1
unnamed: D9.2 (A), R29.1
unnamed: D10.2 (A), R30.1
unnamed: D11.2 (A), R31.1
unnamed: JP1.2 (B), R36.1
unnamed: Q2.3 (D), R7.2
unnamed: Q4.1 (B), Q4.3 (C), Q7.1 (B), R20.2
unnamed: Q6.1 (G), Q7.3 (C), R23.2
unnamed: Q9.1 (B), R32.1
unnamed: Q9.3 (C), R33.1, U3.2 (~RE), U3.3 (DE)
RS485_MD_A: J5.4, J6.4, JP1.1 (A), R34.2, U3.6 (A)
RS485_MD_B: J5.5, J6.5, R35.1, R36.2, U3.7 (B)
Slide_Switch1: R3.1, SW2.1 (A), U2.15 (PB1)
Slide_Switch2: R4.1, SW3.1 (A), U2.22 (PA12)
TCK: J3.3, U2.24 (PA14)
TMS: J3.5, U2.23 (PA13)
Tact_Switch1: R1.2, SW1.1 (A), U2.18 (PA8)
Tact_Switch2: R5.2, SW4.1 (A), U2.21 (PA11)
VBUS: C4.1, J3.1, Q5.2 (S), R19.2, R29.2
VCC: C6.1, C7.1, D2.1 (K), D6.1 (K), R15.2, U1.1 (VI)
VDD: D2.2 (A), Q3.1 (D), Q3.2 (D), Q3.5 (D), Q3.6 (D)
主電源スイッチ: Q2.1 (G), R8.1, SW5.1 (A)

Notes on the sheet:
Conn to Main
保護回路・スイッチ
タクトスイッチ
LED
I/O
モタドラ
STLink
スライドスイッチ
3.3V生成
F303K8
書き込み
NRST
Capacitor
BOOT0
Conn
Encoder
PowerModule
E3V3
U3V3
パスコン
Indicator
4Pスイッチ
マイコン
MAX3485
主電源スイッチ

Board: 2 copper layers, 80 parts (0 on the bottom side), 47 nets, no tracks yet.

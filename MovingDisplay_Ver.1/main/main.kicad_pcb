# Repository Tomoshibi-technology/Tomoshibi_Circuit

## KiCad design MovingDisplay_Ver.1/main/main.kicad_pcb

Parts:
C1, C26: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C6, C10, C11: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C4, C7, C8, C9, C14, C18, C19, C20, C23, C24, C25, C28, C29, C30, C31, C32, C33, C34, C36: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C16: 470uF; C_Elec_8x10.2
C12, C13, C17, C21, C22, C27, C35: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C15: ADJ_ST; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1, D4, D5, D7: D; D_SOD-123
D2, D3, D6, D8, D9, D10, D11, D12, D13, D14, D15, D16: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2: MountingHole_Pad; TestPoint_Pad_2.0x2.0mm
H3, H4, H5: MountingHole_Pad; TestPoint_THTPad_2.5x2.5mm_Drill1.2mm
J1: Conn_01x02_Female; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2: Conn_01x06_Female; Molex_PicoBlade_53261-0671_1x06-1MP_P1.25mm_Horizontal
J3, J5: USB_C_Receptacle_USB2.0; USB_C(simple)
J4: Conn_01x07_Female; PinSocket_1x07_P2.54mm_Horizontal
J6: Conn_01x10_Female; IDC-Header_2x05_P2.54mm_Horizontal
J7, J8, J9, J10: Conn_01x05_Female; Molex_PicoBlade_53261-0571_1x05-1MP_P1.25mm_Horizontal
J11: Conn_01x09_Female; Molex_PicoBlade_53261-0971_1x09-1MP_P1.25mm_Horizontal
J12: Conn_01x10_Female; Molex_PicoBlade_53261-1071_1x10-1MP_P1.25mm_Horizontal
J13, J14, J15, J16: Conn_01x03_Female; Molex_PicoBlade_53261-0371_1x03-1MP_P1.25mm_Horizontal
JP1, JP2, JP3, JP4: Jumper_3_Open; PinHeader_1x03_P2.54mm_Vertical
JP5: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
JP6, JP7, JP8, JP9: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
LS1: Speaker_Crystal; Buzzer_12x9.5RM7.6
Q1, Q3, Q4, Q5, Q8, Q9, Q11, Q17, Q18, Q19, Q20, Q25: PMN48XP; SSM6J808R
Q2, Q6, Q12, Q21, Q22, Q23, Q24: Q_NMOS_GSD; SOT-23_Handsoldering
Q7, Q10, Q14: Q_PNP_BEC; SC-59_Handsoldering
Q13, Q15, Q16: Q_PMOS_GSD; SOT-23_Handsoldering
R1, R3, R9, R13, R14, R15, R16, R18, R19, R20, R21, R22, R23, R25, R26, R27, R28, R29, R30, R31, R37, R38, R43, R44, R45, R46, R49, R50, R53, R54, R55, R56, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R4, R10, R11: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6, R12, R17, R24, R32, R33, R34, R35, R36, R39, R40, R47, R48: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8, R41, R42: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R51: 7.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R52: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R57, R58: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R59: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_SPDT; 3P_SPDT_5Pin_ToggleSwitch
SW2, SW4, SW6, SW9, SW10, SW14: SW_SPDT; 3P_SPDT_SlideSwitch
SW3, SW7, SW8, SW11: SW_SPST; SW_SPST_Omron_B3FS-100xP
SW5, SW12: SW_DIP_x04; DIP-8_W7.62mm
SW13: SW_DPDT_x2; SW_CuK_JS202011CQN_DPDT_Straight
U1, U2: CH340E; MSOP-10_3x3mm_P0.5mm
U3, U4: LF50_TO220; BP5293
U5: AMS1117CD-3.3; TO-252-3_TabPin2
U6: TWE-L-WX; MonoWireless_TWE-L-WX
U7: STM32F446RETx; LQFP-64_10x10mm_P0.5mm
U8: BNO055
U9: MAX3485; SOP-8_3.9x4.9mm_P1.27mm
U10: DFR0299; MODULE_DFR0299

Connections:
+3.3V: C18.1, C19.1, C20.1, C21.2, C22.1, C24.1, C25.1, C27.1, C28.1, C29.1, C30.1, C31.1, D7.2 (A), H5.1, J6.2, Q14.2 (E), Q16.2 (S), R17.1, R18.1, R19.1, R31.1, R38.2, R41.1, R42.1, R54.1, R57.1, SW5.5, SW5.6, SW5.7, SW5.8, SW6.2 (B), SW8.2 (B), SW9.2 (B), SW10.2 (B), SW11.2 (B), U5.2 (VO), U6.5 (VCC), U7.1 (VBAT), U7.13 (VDDA), U7.19 (VDD), U7.32 (VDD), U7.48 (VDD), U7.64 (VDD), U8.3 (VDD), U9.8 (VCC)
+5V: C16.1, C17.1, D7.1 (K), H3.1, Q9.4 (S), Q10.2 (E), Q11.4 (S), Q13.2 (S), Q15.2 (S), Q25.4 (S), R26.2, R35.2, R49.1, R53.1, R70.1, U5.3 (VI)
+12V: J1.2, Q1.1 (D), Q1.2 (D), Q1.5 (D), Q1.6 (D)
/5V_UI: C12.1, D4.2 (A), J11.2, J12.2, R15.2, U3.3 (VO)
/S-S: C1.1, D1.1 (K), Q1.4 (S), Q3.4 (S), R1.1, R3.1, SW1.2 (B)
/Twe_VBUS: C2.2, C3.1, J3.A4 (VBUS), Q4.1 (D), Q4.2 (D), Q4.5 (D), Q4.6 (D), U1.7 (VCC)
/VSYS: C13.1, D5.2 (A), Q7.2 (E), Q9.1 (D), Q9.2 (D), Q9.5 (D), Q9.6 (D), R16.2, R23.1, R24.2, R32.2, U4.3 (VO)
BOOT0: R36.2, R37.1, SW6.1 (A), U7.60 (BOOT0)
Buzzer: Q12.1 (G), R50.1, U7.10 (PC2)
DAC_L: J13.3, J14.3, J15.3, J16.3, U10.5 (DAC_L)
DAC_R: J13.2, J14.2, J15.2, J16.2, U10.4 (DAC_R)
DFPlayer_Pw: C35.1, Q25.1 (D), Q25.2 (D), Q25.5 (D), Q25.6 (D), U10.1 (VCC)
Display1_H: J2.3, Q21.3 (D), R66.1
Display1_L: Q21.2 (S), R62.1, U7.37 (PC6)
Display2_H: J2.4, Q22.3 (D), R67.1
Display2_L: Q22.2 (S), R63.1, U7.38 (PC7)
Display3_H: J2.5, Q23.3 (D), R68.1
Display3_L: Q23.2 (S), R64.1, U7.39 (PC8)
Display4_H: J2.6, Q24.3 (D), R69.1
Display4_L: Q24.2 (S), R65.1, U7.40 (PC9)
Display_Pw_H: Q15.3 (D), R66.2, R67.2, R68.2, R69.2
Display_Pw_L: Q16.3 (D), Q21.1 (G), Q22.1 (G), Q23.1 (G), Q24.1 (G), R62.2, R63.2, R64.2, R65.2
F446USBRX: JP4.1 (A), U2.9 (RXD)
F446USBTX: JP3.1 (A), U2.8 (TXD)
GND: C2.1, C3.2, C4.2, C5.2, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.1, C16.2, C17.2, C18.2, C19.2, C20.2, C21.1, C22.2, C23.2, C24.2, C25.2, C26.1, C27.2, C29.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, D1.2 (A), D2.1 (K), D3.1 (K), D6.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), H4.1, J1.1, J2.1, J2.2, J3.A1 (GND), J3.S1 (SHIELD), J4.1, J5.A1 (GND), J5.S1 (SHIELD), J6.4, J7.1, J8.1, J9.1, J10.1, J11.1, J12.1, J13.1, J14.1, J15.1, J16.1, LS1.2, Q1.3 (G), Q2.2 (S), Q6.2 (S), Q12.2 (S), R1.2, R2.1, R4.1, R8.2, R9.2, R10.1, R11.1, R13.1, R15.1, R16.1, R20.1, R21.1, R22.1, R24.1, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R37.2, R38.1, R43.1, R44.2, R45.2, R46.1, R50.2, R52.2, R58.2, SW2.2 (B), SW3.2 (B), SW4.2 (B), SW7.2 (B), SW12.5, SW12.6, SW12.7, SW12.8, SW13.2 (B), SW13.5 (B), SW14.2 (B), U1.3 (GND), U2.3 (GND), U3.2 (GND), U4.2 (GND), U5.1 (GND), U6.20 (GND), U6.22 (ADC2/AI3), U6.23 (ADC1/AI1), U6.28 (GND), U6.30 (GND), U6.31 (GND), U6.32 (GND), U7.12 (VSSA), U7.18 (VSS), U7.31 (VSS), U7.47 (VSS), U7.63 (VSS), U8.2 (GND), U9.5 (GND), U10.7 (GND), U10.10 (GND)
I2C1_SCL: R42.2, U7.61 (PB8), U8.19 (COM1)
I2C1_SDA: R41.2, U7.62 (PB9), U8.20 (COM0)
IndicatorLED: Q8.1 (D), Q8.2 (D), Q8.5 (D), Q8.6 (D), Q11.1 (D), Q11.2 (D), Q11.5 (D), Q11.6 (D), R34.2
LED1: R47.2, U7.26 (PB0)
LED2: R48.2, U7.25 (PC5)
MD1: Q17.3 (G), R55.1, SW12.1
MD1_GPIO: JP6.2 (B), U7.2 (PC13)
MD1_Pw: C32.1, J7.2, Q17.1 (D), Q17.2 (D), Q17.5 (D), Q17.6 (D)
MD2: Q18.3 (G), R56.1, SW12.2
MD2_GPIO: JP7.2 (B), U7.11 (PC3)
MD2_Pw: C33.1, J8.2, Q18.1 (D), Q18.2 (D), Q18.5 (D), Q18.6 (D)
MD3: Q19.3 (G), R60.1, SW12.3
MD3_GPIO: JP8.2 (B), U7.9 (PC1)
MD3_Pw: C34.1, J9.2, Q19.1 (D), Q19.2 (D), Q19.5 (D), Q19.6 (D)
MD4: Q20.3 (G), R61.1, SW12.4
MD4_GPIO: JP9.2 (B), U7.20 (PA4)
MD4_Pw: C36.1, J10.2, Q20.1 (D), Q20.2 (D), Q20.5 (D), Q20.6 (D)
MainRX1_DFPlayerTX: U7.59 (PB7), U10.3 (TX)
MainRX2_F446WriteTX: JP3.2 (C), U7.17 (PA3)
MainRX3_M5TX: J11.8, U7.52 (PC11)
MainRX4_TweTX1: U6.14 (DIO14/SCL), U7.15 (PA1)
MainRX5_MDTX: U7.54 (PD2), U9.1 (RO)
MainTX1_DFPlayerRX: U7.58 (PB6), U10.2 (RX)
MainTX2_F446WriteRX: JP4.2 (C), U7.16 (PA2)
MainTX3_M5RX: J11.9, U7.51 (PC10)
MainTX4_TweRX1: U6.17 (DIO15/SDA), U7.14 (PA0)
MainTX5_MDRX: R51.2, U7.53 (PC12), U9.4 (DI)
NRST: C23.1, J6.6, R31.2, SW7.1 (A), U2.4 (~RTS), U7.7 (NRST)
unnamed: C1.2, Q3.3 (G), R3.2, R5.1
unnamed: C4.1, U1.10 (V3)
unnamed: C8.1, U2.10 (V3)
unnamed: C15.2, Q8.3 (G), Q11.3 (G), R23.2
unnamed: C26.2, U7.30 (VCAP_1)
unnamed: D2.2 (A), R6.1
unnamed: D3.2 (A), R12.1
unnamed: D6.2 (A), Q6.3 (D), R17.2
unnamed: D8.2 (A), R32.1
unnamed: D9.2 (A), R33.1
unnamed: D10.2 (A), R34.1
unnamed: D11.2 (A), R35.1
unnamed: D12.2 (A), R36.1
unnamed: D13.2 (A), R39.1
unnamed: D14.2 (A), R40.1
unnamed: D15.2 (A), R47.1
unnamed: D16.2 (A), R48.1
unnamed: H1.1, U1.5 (~CTS)
unnamed: J3.A5 (CC1), R4.2
unnamed: J3.A6 (D+), U1.1 (UD+)
unnamed: J3.A7 (D-), U1.2 (UD-)
unnamed: J3.B5 (CC2), R2.2
unnamed: J5.A5 (CC1), R11.2
unnamed: J5.A6 (D+), U2.1 (UD+)
unnamed: J5.A7 (D-), U2.2 (UD-)
unnamed: J5.B5 (CC2), R10.2
unnamed: J7.3, JP6.1 (A)
unnamed: J8.3, JP7.1 (A)
unnamed: J9.3, JP8.1 (A)
unnamed: J10.3, JP9.1 (A)
unnamed: JP5.2 (B), R59.1
unnamed: LS1.1, Q13.3 (D)
unnamed: Q2.3 (D), R5.2
unnamed: Q4.3 (G), Q5.3 (G), R14.1, SW2.1 (A)
unnamed: Q4.4 (S), Q5.4 (S), R14.2
unnamed: Q7.1 (B), Q7.3 (C), Q10.1 (B), R22.2
unnamed: Q9.3 (G), Q10.3 (C), R25.2
unnamed: Q12.3 (D), Q13.1 (G), R49.2
unnamed: Q14.1 (B), R51.1
unnamed: Q14.3 (C), R52.1, U9.2 (~RE), U9.3 (DE)
unnamed: Q15.1 (G), R53.2, SW13.1 (A)
unnamed: Q16.1 (G), R54.2, SW13.4 (A)
unnamed: Q25.3 (G), R70.2, SW14.1 (A)
unnamed: R6.2, U1.6 (TNOW)
unnamed: R12.2, U2.6 (TNOW)
PRG: H2.1, J4.3, Q6.1 (G), R19.2, R20.2, SW4.1 (A), U6.2 (DO1/PWM3)
RS485_MD_A: J7.4, J8.4, J9.4, J10.4, JP5.1 (A), R57.2, U9.6 (A)
RS485_MD_B: J7.5, J8.5, J9.5, J10.5, R58.1, R59.2, U9.7 (B)
RST: C14.1, J4.5, R18.2, SW3.1 (A), U1.4 (~RTS), U6.21 (~RESET)
SET: J4.7, U6.13 (DIO12/DI1)
STLinkRX: J6.9, JP4.3 (B)
STLinkTX: J6.8, JP3.3 (B)
SWO: J6.7, U7.55 (PB3)
Slide_Switch1: R44.1, SW9.1 (A), U7.28 (PB2)
Slide_Switch2: R45.1, SW10.1 (A), U7.27 (PB1)
TCK: J6.3, U7.49 (PA14)
TMS: J6.5, U7.46 (PA13)
Tact_Switch1: C28.2, R43.2, SW8.1 (A), U7.24 (PC4)
Tact_Switch2: C30.2, R46.2, SW11.1 (A), U7.23 (PA7)
TweR3RX: J4.2, JP2.3 (B)
TweR3TX: J4.4, JP1.3 (B)
TweUSBRX: JP2.1 (A), U1.9 (RXD)
TweUSBTX: JP1.1 (A), U1.8 (TXD)
TweWriteRX_TweTX0: JP2.2 (C), U6.8 (DIO6/TX)
TweWriteTX_TweRX0: JP1.2 (C), U6.9 (DIO7/RX)
Twe_LED1: R39.2, U6.3 (DIO18/DO1)
Twe_LED2: R40.2, U6.4 (DIO19/DO2)
Twe_SW1: R27.2, SW5.1, U6.10 (DIO8/PWM4)
Twe_SW2: R28.2, SW5.2, U6.11 (DIO9/DO4)
Twe_SW3: R29.2, SW5.3, U6.15 (DIO13/DI2)
Twe_SW4: R30.2, SW5.4, U6.18 (DIO16/DI4)
UI_ADC1: J12.10, U7.22 (PA6)
UI_LED1: J11.3, U7.43 (PA10)
UI_LED2: J11.4, U7.44 (PA11)
UI_LED3: J11.5, U7.45 (PA12)
UI_LED4: J11.6, U7.50 (PA15)
UI_LED5: J11.7, U7.57 (PB5)
UI_Tact1: J12.7, U7.36 (PB15)
UI_Tact2: J12.8, U7.41 (PA8)
UI_Tact3: J12.9, U7.42 (PA9)
UI_TactLED1: J12.4, U7.33 (PB12)
UI_TactLED2: J12.5, U7.34 (PB13)
UI_TactLED3: J12.6, U7.35 (PB14)
UI_Toggle1: J12.3, U7.29 (PB10)
VBUS: C6.2, C7.1, C9.1, J5.A4 (VBUS), J6.1, Q5.1 (D), Q5.2 (D), Q5.5 (D), Q5.6 (D), Q8.4 (S), Q17.4 (S), Q18.4 (S), Q19.4 (S), Q20.4 (S), R21.2, R33.2, R55.2, R56.2, R60.2, R61.2, U2.7 (VCC)
VDD: C5.1, C10.1, C11.1, D4.1 (K), D5.1 (K), Q3.1 (D), Q3.2 (D), Q3.5 (D), Q3.6 (D), R7.1, R13.2, U3.1 (VI), U4.1 (VI)
V_Measure: R7.2, R8.1, U7.8 (PC0)
gyro_reset: U7.21 (PA5), U8.11 (~RESET)
主電源スイッチ: Q2.1 (G), R9.1, SW1.1 (A)

Notes on the sheet:
UI基板用5V
USB-C
レベル変換
主電源スイッチ
保護回路・スイッチ
DFPlayerMini
5V生成
PowerModule
書き込み
TweLite
Conn to Amplifier
パワースイッチ
パスコン
リセット
NRST
BNO055
E5V
LED
スライドスイッチ
U5V
制御スイッチ
タクトスイッチ
UI基板
F446RE
モタドラ
3.3V生成
電源切替
TweLiteR3
DFPlayer Mini
マイコン
PRG
BOOT0
Conn to MD
インジケーターLED
DIPスイッチ
I/O
Display
Jumper
STLink
MAX3485

Board: 2 copper layers, 110.0 x 120.0 mm, 202 parts (74 on the bottom side), 142 nets.

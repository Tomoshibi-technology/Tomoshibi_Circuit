# Repository Tomoshibi-technology/Tomoshibi_Circuit (continued)

## KiCad design projects/For Harvest Festival/ESP32/ESP32.kicad_pcb

Parts:
C1, C17: 10uF; C_0805_2012Metric
C2, C3, C4, C13, C14, C15, C16, C20, C21, C22, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43: 0.1uF; C_0402_1005Metric
C5, C7, C8: 470uF; C_Elec_8x10.2
C6, C18: 4.7uF; C_0603_1608Metric
C9: ADJ_ST; C_Disc_D5.0mm_W2.5mm_P5.00mm
C10, C11, C12: 1uF; C_0402_1005Metric
C19: 22uF; C_0805_2012Metric
C23: C; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D3: D; D_SOD-123
D2: D_Schottky; D_SOD-123
D4, D5, D6, D7, D9, D10, D51: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D8: D_Zener; D_SOD-323_HandSoldering
D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50: WS2812C-2020-V1
F1: Fuse; FUC_03A
H1, H2, H5, H6, H7, H8: MountingHole_Pad; TestPoint_Pad_1.5x1.5mm
J1: USB_C_Receptacle_USB2.0; USB_C(simple)
J2, J9: Conn_01x02_Female; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J3, J4: Conn_01x05_Female; Molex_SPOX_5268-05A_1x05_P2.50mm_Horizontal
J5, J6, J7, J8: Conn_01x03_Female; Molex_SPOX_5267-03A_1x03_P2.50mm_Vertical
J10: USB_C_Receptacle_USB2.0; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
JP1: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
JP2, JP3, JP4: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
JP5: SolderJumper_3_Open; SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm_NumberLabels
LS1: Speaker; Buzzer_Murata_PKLCS1212E
MK1: Microphone_Condenser; C9767
Q1, Q5, Q8: Q_PNP_BEC; SC-59_Handsoldering
Q2, Q4: PMN48XP; UDFN6
Q3, Q12, Q13, Q14, Q15, Q20: Q_NMOS_GSD; SOT-23
Q6, Q7, Q9, Q18: PMN48XP; SSM6J808R
Q10, Q11, Q19: Q_PMOS_GSD; SOT-23
Q16, Q17: Q_NPN_BEC; SC-59_Handsoldering
R1: 7.5k; R_0603_1608Metric
R2, R4: 5.1k; R_0402_1005Metric
R3: 20k; R_0402_1005Metric
R5, R10, R11, R13, R14, R15, R16, R18, R19, R24, R26, R27, R32, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65: 10k; R_0402_1005Metric
R6, R28, R49, R51: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8: 2.2k; R_0402_1005Metric
R9: 120; R_0402_1005Metric
R12, R17, R20, R21, R22, R23, R25, R29, R30, R67: 1k; R_0402_1005Metric
R31, R33, R34, R48: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R47: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R50: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1: R_Potentiometer; TSR-3386K
SW1: SW_SPDT; 3P_SPDT_5Pin_ToggleSwitch
SW2: SW_DIP_x02; DIP-4_W7.62mm
SW3, SW4: SW_SPDT; 3P_SPDT_SlideSwitch
SW5, SW6, SW7, SW9, SW10: SW_SPST; SW_SPST_Omron_B3FS-100xP
SW8, SW12: SW_DPDT_x2; SW_CuK_JS202011CQN_DPDT_Straight
SW11: SW_DIP_x04; DIP-8_W7.62mm
TP1, TP2, TP3, TP4, TP5: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: MAX3485; SOP-8_3.9x4.9mm_P1.27mm
U2: CH340K
U3: AMS1117CD-3.3; TO-252-3_TabPin2
U4: NJU72501_Module; DIP-8_W7.62mm
U5: OLED_akitsuki; 128×64_OLED_White
U6: NJM4558; DIP-8_W7.62mm
U7: AE-MICAMP
U8: ESP32-WROOM-32

Connections:
+3.3V: C2.2, C4.1, C8.1, C11.1, C12.2, C15.1, C19.1, C22.1, D3.2 (A), D8.1 (K), JP4.1 (A), Q1.2 (E), Q11.2 (S), Q19.2 (S), R6.2, R7.1, R24.2, R32.2, R33.1, R34.1, R35.2, R37.1, R38.2, R47.2, R54.1, R55.1, R63.1, SW2.3, SW2.4, SW3.2 (B), SW4.2 (B), SW11.5, SW11.6, SW11.7, SW11.8, TP4.1, U1.8 (VCC), U2.7 (VCC), U3.2 (VO), U4.1 (VIN), U5.2 (VCC), U6.8 (V+), U7.1 (VCC), U8.2 (VDD)
+5V: F1.2, J2.2, J9.2, TP1.1
/CC1: J1.A5 (CC1), J10.A5 (CC1), R4.2
/CC2: J1.B5 (CC2), J10.B5 (CC2), R2.2
/D+: J1.A6 (D+), J10.A6 (D+), J10.B6 (D+), U2.1 (UD+)
/D-: J1.A7 (D-), J10.A7 (D-), J10.B7 (D-), U2.2 (UD-)
/S-S: C6.1, D1.1 (K), Q2.4 (S), Q4.4 (S), R10.1, R11.1, SW1.2 (B)
/VSYS: D2.1 (K), Q5.2 (E), Q7.1 (D), Q7.2 (D), Q7.5 (D), Q7.6 (D), R13.2, R16.1, R17.2, R20.2
Amp_OUT: H6.1, JP5.3 (B), R51.1, U6.1
BOOT: C21.1, H2.1, Q17.3 (C), R55.2, SW10.1 (A), U8.25 (IO0)
DIP_SW1: R56.2, SW11.1, U8.10 (IO25)
DIP_SW2: R57.2, SW11.2, U8.30 (IO18)
DIP_SW3: R58.2, SW11.3, U8.31 (IO19)
DIP_SW4: R59.2, SW11.4, U8.37 (IO23)
DOUT: D50.1 (DOUT), H8.1
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C7.2, C8.2, C9.1, C10.2, C11.2, C12.1, C13.2, C14.2, C15.2, C16.2, C17.2, C19.2, C20.2, C21.2, C22.2, C23.1, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, D1.2 (A), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.2 (A), D9.1 (K), D10.1 (K), D11.2 (GND), D12.2 (GND), D13.2 (GND), D14.2 (GND), D15.2 (GND), D16.2 (GND), D17.2 (GND), D18.2 (GND), D19.2 (GND), D20.2 (GND), D21.2 (GND), D22.2 (GND), D23.2 (GND), D24.2 (GND), D25.2 (GND), D26.2 (GND), D27.2 (GND), D28.2 (GND), D29.2 (GND), D30.2 (GND), D31.2 (GND), D32.2 (GND), D33.2 (GND), D34.2 (GND), D35.2 (GND), D36.2 (GND), D37.2 (GND), D38.2 (GND), D39.2 (GND), D40.2 (GND), D41.2 (GND), D42.2 (GND), D43.2 (GND), D44.2 (GND), D45.2 (GND), D46.2 (GND), D47.2 (GND), D48.2 (GND), D49.2 (GND), D50.2 (GND), D51.1 (K), J1.A1 (GND), J1.S1 (SHIELD), J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.A1 (GND), J10.A12 (GND), J10.B1 (GND), J10.B12 (GND), J10.S1 (SHIELD), MK1.1 (-), Q2.3 (G), Q3.2 (S), R2.1, R3.2, R4.1, R5.2, R8.2, R10.2, R13.1, R14.1, R15.1, R17.1, R18.1, R19.1, R24.1, R26.2, R27.1, R28.1, R56.1, R57.1, R58.1, R59.1, R60.1, R61.1, SW5.2 (B), SW6.2 (B), SW7.2 (B), SW8.2 (B), SW8.5 (B), SW9.2 (B), SW10.2 (B), SW12.2 (B), SW12.5 (B), TP5.1, U1.5 (GND), U2.3 (GND), U2.11 (EP), U3.1 (GND), U4.2 (GND), U4.4 (GND), U5.1 (GND), U6.4 (V-), U7.2 (GND), U8.1 (GND), U8.15 (GND), U8.38 (GND), U8.39 (GND)
I2C0_SCL: R33.2, U5.3 (SCL), U8.36 (IO22)
I2C0_SDA: R34.2, U5.4 (SDA), U8.33 (IO21)
IndicatorLED: Q6.1 (D), Q6.2 (D), Q6.5 (D), Q6.6 (D), Q9.1 (D), Q9.2 (D), Q9.5 (D), Q9.6 (D), R22.2
LED1: R29.2, U8.24 (IO2)
LED2: R30.2, U8.14 (IO12)
LEDTape1_H: J5.3, Q12.3 (D), R43.1
LEDTape1_L: Q12.2 (S), R39.1, U8.8 (IO32)
LEDTape2_H: J6.3, Q13.3 (D), R44.1
LEDTape2_L: Q13.2 (S), R40.1, U8.13 (IO14)
LEDTape3_H: J7.3, Q14.3 (D), R45.1
LEDTape3_L: Q14.2 (S), R41.1, U8.16 (IO13)
LEDTape4_H: J8.3, Q15.3 (D), R46.1
LEDTape4_L: Q15.2 (S), R42.1, U8.9 (IO33)
LEDTape_PW_H: Q10.3 (D), R43.2, R44.2, R45.2, R46.2
LEDTape_PW_L: Q11.3 (D), Q12.1 (G), Q13.1 (G), Q14.1 (G), Q15.1 (G), R39.2, R40.2, R41.2, R42.2
MainRX0_CH340TX: U2.8 (TXD), U8.34 (RXD0/IO3)
MainRX2_RS485TX: U1.1 (RO), U8.27 (IO16)
MainTX0_CH340RX: U2.9 (RXD), U8.35 (TXD0/IO1)
MainTX2_RS485RX: R1.2, U1.4 (DI), U8.28 (IO17)
Mic: H5.1, JP5.2 (C), U8.7 (IO35)
Module_OUT: H7.1, JP5.1 (A), U7.3 (OUT)
NeoPixel_H: D11.3 (DIN), Q20.3 (D), R65.1
NeoPixel_L: Q20.2 (S), R64.1, U8.12 (IO27)
NeoPixel_PW_H: C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, D11.4 (VDD), D12.4 (VDD), D13.4 (VDD), D14.4 (VDD), D15.4 (VDD), D16.4 (VDD), D17.4 (VDD), D18.4 (VDD), D19.4 (VDD), D20.4 (VDD), D21.4 (VDD), D22.4 (VDD), D23.4 (VDD), D24.4 (VDD), D25.4 (VDD), D26.4 (VDD), D27.4 (VDD), D28.4 (VDD), D29.4 (VDD), D30.4 (VDD), D31.4 (VDD), D32.4 (VDD), D33.4 (VDD), D34.4 (VDD), D35.4 (VDD), D36.4 (VDD), D37.4 (VDD), D38.4 (VDD), D39.4 (VDD), D40.4 (VDD), D41.4 (VDD), D42.4 (VDD), D43.4 (VDD), D44.4 (VDD), D45.4 (VDD), D46.4 (VDD), D47.4 (VDD), D48.4 (VDD), D49.4 (VDD), D50.4 (VDD), Q18.1 (D), Q18.2 (D), Q18.5 (D), Q18.6 (D), R65.2
NeoPixel_PW_L: Q19.3 (D), Q20.1 (G), R64.2
unnamed: C3.1, JP4.2 (B), U2.10 (V3)
unnamed: C6.2, Q4.3 (G), R11.2, R12.1
unnamed: C9.2, Q6.3 (G), Q9.3 (G), R16.2
unnamed: C17.1, R6.1, R28.2, R31.2
unnamed: C18.1, MK1.2 (+), R47.1
unnamed: C18.2, R49.2, U6.3 (+)
unnamed: D4.2 (A), R20.1
unnamed: D5.2 (A), R21.1
unnamed: D6.2 (A), R22.1
unnamed: D7.2 (A), R23.1
unnamed: D9.2 (A), R29.1
unnamed: D10.2 (A), R30.1
unnamed: D11.1 (DOUT), D15.3 (DIN)
unnamed: D12.1 (DOUT), D16.3 (DIN)
unnamed: D12.3 (DIN), D27.1 (DOUT)
unnamed: D13.1 (DOUT), D17.3 (DIN)
unnamed: D13.3 (DIN), D28.1 (DOUT)
unnamed: D14.1 (DOUT), D18.3 (DIN)
unnamed: D14.3 (DIN), D29.1 (DOUT)
unnamed: D15.1 (DOUT), D19.3 (DIN)
unnamed: D16.1 (DOUT), D20.3 (DIN)
unnamed: D17.1 (DOUT), D21.3 (DIN)
unnamed: D18.1 (DOUT), D22.3 (DIN)
unnamed: D19.1 (DOUT), D23.3 (DIN)
unnamed: D20.1 (DOUT), D24.3 (DIN)
unnamed: D21.1 (DOUT), D25.3 (DIN)
unnamed: D22.1 (DOUT), D26.3 (DIN)
unnamed: D23.1 (DOUT), D27.3 (DIN)
unnamed: D24.1 (DOUT), D28.3 (DIN)
unnamed: D25.1 (DOUT), D29.3 (DIN)
unnamed: D26.1 (DOUT), D30.3 (DIN)
unnamed: D30.1 (DOUT), D31.3 (DIN)
unnamed: D31.1 (DOUT), D35.3 (DIN)
unnamed: D32.1 (DOUT), D36.3 (DIN)
unnamed: D32.3 (DIN), D47.1 (DOUT)
unnamed: D33.1 (DOUT), D37.3 (DIN)
unnamed: D33.3 (DIN), D48.1 (DOUT)
unnamed: D34.1 (DOUT), D38.3 (DIN)
unnamed: D34.3 (DIN), D49.1 (DOUT)
unnamed: D35.1 (DOUT), D39.3 (DIN)
unnamed: D36.1 (DOUT), D40.3 (DIN)
unnamed: D37.1 (DOUT), D41.3 (DIN)
unnamed: D38.1 (DOUT), D42.3 (DIN)
unnamed: D39.1 (DOUT), D43.3 (DIN)
unnamed: D40.1 (DOUT), D44.3 (DIN)
unnamed: D41.1 (DOUT), D45.3 (DIN)
unnamed: D42.1 (DOUT), D46.3 (DIN)
unnamed: D43.1 (DOUT), D47.3 (DIN)
unnamed: D44.1 (DOUT), D48.3 (DIN)
unnamed: D45.1 (DOUT), D49.3 (DIN)
unnamed: D46.1 (DOUT), D50.3 (DIN)
unnamed: D51.2 (A), R67.1
unnamed: F1.1, Q2.1 (D), Q2.2 (D), Q2.5 (D), Q2.6 (D)
unnamed: J3.3, JP2.1 (A)
unnamed: J4.3, JP3.1 (A)
unnamed: JP1.2 (B), R9.1
unnamed: LS1.1, R25.1, RV1.2, RV1.3
unnamed: LS1.2, R25.2, U4.7 (VO2)
unnamed: Q1.1 (B), R1.1
unnamed: Q1.3 (C), R3.1, U1.2 (~RE), U1.3 (DE)
unnamed: Q3.3 (D), R12.2
unnamed: Q5.1 (B), Q5.3 (C), Q8.1 (B), R15.2
unnamed: Q7.3 (G), Q8.3 (C), R18.2
unnamed: Q10.1 (G), R36.2, SW8.1 (A)
unnamed: Q11.1 (G), R37.2, SW8.4 (A)
unnamed: Q16.1 (B), R52.1
unnamed: Q16.2 (E), R53.2, U2.6 (~RTS)
unnamed: Q17.1 (B), R53.1
unnamed: Q17.2 (E), R52.2, U2.4 (~DTR)
unnamed: Q18.3 (G), R62.2, SW12.1 (A)
unnamed: Q19.1 (G), R63.2, SW12.4 (A)
unnamed: R31.1, U6.5 (+)
unnamed: R48.1, R49.1, R50.1
unnamed: R48.2, U6.6 (-), U6.7
unnamed: R50.2, R51.2, U6.2 (-)
unnamed: R60.2, SW2.1, U4.6 (EN1)
unnamed: R61.2, SW2.2, U4.5 (EN2)
unnamed: RV1.1, U4.8 (VO1)
RESET: C20.1, C23.2, H1.1, Q16.3 (C), R54.2, SW5.1 (A), U8.3 (EN)
RS485_A: J3.4, J4.4, JP1.1 (A), R7.2, U1.6 (A)
RS485_B: J3.5, J4.5, R8.1, R9.2, U1.7 (B)
RS485_GPIO: JP2.2 (B), JP3.2 (B), U8.11 (IO26)
Slide_SW1: R26.1, SW3.1 (A), U8.5 (SENSOR_VN)
Slide_SW2: R27.2, SW4.1 (A), U8.4 (SENSOR_VP)
Speker: U4.3 (DIN), U8.26 (IO4)
Tact_SW1: C13.1, R32.1, SW6.1 (A), U8.6 (IO34)
Tact_SW2: C14.1, R35.1, SW7.1 (A), U8.29 (IO5)
Tact_SW3: C16.1, R38.1, SW9.1 (A), U8.23 (IO15)
VBUS: C1.2, J1.A4 (VBUS), J10.A4 (VBUS), J10.A9 (VBUS), J10.B4 (VBUS), J10.B9 (VBUS), Q6.4 (S), R14.2, R21.2
VCC: C7.1, C10.1, D3.1 (K), Q7.4 (S), Q8.2 (E), Q9.4 (S), Q10.2 (S), Q18.4 (S), R19.2, R23.2, R36.1, R62.1, TP3.1, U3.3 (VI)
VDD: C5.1, D2.2 (A), J5.2, J6.2, J7.2, J8.2, Q4.1 (D), Q4.2 (D), Q4.5 (D), Q4.6 (D), R67.2, TP2.1
主電源スイッチ: Q3.1 (G), R5.1, SW1.1 (A)

Notes on the sheet:
OLED
RS485
switch
Capacitor
I/O
5Pスイッチ
TestPoint
制御スイッチ
RST
レベル変換
Speaker
パスコン
Module
LEDTape
モニター用タクトスイッチ
Amp
主電源スイッチ
MAX3485
NeoPixel
書き込み
U5V
PowerModule
保護回路・スイッチ
LED
3.3V生成
電源切替
E5V
モニター
Mic
Conn
BOOT
Switch
Conn to LEDTape
インジケーターLED
マイコン

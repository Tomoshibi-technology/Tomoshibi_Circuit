# Repository Tomoshibi-technology/Tomoshibi_Circuit

## KiCad design projects/MovingDisplay_Ver.2/Power/Power.kicad_pcb

Parts:
C1: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 470uF; C_Elec_8x10.2
D1: D; D_SOD-123
F1: Fuse; Fuseholder_Blade_Mini_Keystone_3568
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x02_Female; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J2: Conn_01x02_Female; Molex_SPOX_5268-02A_1x02_P2.50mm_Horizontal
J3, J4, J5, J6, J7, J8, J9, J10, J11, J12: Conn_01x02_Female; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
K1: RAYEX-L90; TRV4-L-12V-Z-F
MES1: Voltmeter_DC; SuperSmallVoltmeter_twoline
Q1, Q2, Q3, Q4: Q_PMOS_GDS; TO-252-3_TabPin2
Q5: Q_NMOS_GSD; SOT-23_Handsoldering
R1, R2, R6: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4: 510; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_SPST; DS-850K-S-ON

Connections:
30: F1.2, J2.1, K1.11A
85: J2.2, K1.A1
87: K1.14, Q1.2 (D), Q2.2 (D)
+12V: F1.1, J1.2
/S-S: C1.1, D1.1 (K), Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), R1.2, R2.1, SW1.2 (B)
GND: C2.2, D1.2 (A), J1.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, J12.1, K1.A2, MES1.1 (-), Q1.1 (G), Q2.1 (G), Q5.2 (S), R1.1, R6.2
unnamed: Q3.1 (G), R3.1
unnamed: Q4.1 (G), R4.2
unnamed: Q5.1 (G), R6.1, SW1.1 (A)
unnamed: Q5.3 (D), R5.1
VDD: C2.1, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, J9.2, J10.2, J11.2, J12.2, MES1.2 (+), Q3.2 (D), Q4.2 (D)
主電源スイッチ: C1.2, R2.2, R3.2, R4.1, R5.2

Notes on the sheet:
主電源スイッチ
ねじ穴
Conn to Battery
保護回路・スイッチ
Relay
Conn to CircuitBoard
Fuse
非常停止スイッチ

Board: 2 copper layers, 110.0 x 90.0 mm, 34 parts (2 on the bottom side), 12 nets.

## KiCad design projects/MovingDisplay_Ver.2/StepDown/StepDown.kicad_pcb

Board: 2 copper layers, 20 parts (0 on the bottom side), 11 nets, no tracks yet.

Parts:
C1: 22uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C2: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: D; D_SOD-123
D2: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
H1, H2, H3, H4: MountingHole_Pad; TestPoint_THTPad_D3.0mm_Drill1.5mm
J1, J2: Conn_01x02_Female; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J3, J4: Conn_01x02_Female; Molex_SPOX_5268-02A_1x02_P2.50mm_Horizontal
MD1: OKL-T/6-W12N-C; MURATA_OKL-T-6-W12N-C
R1: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 10; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 1.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_SPDT; 3P_SPDT_SlideSwitch

Connections:
+5V: C2.1, D1.2 (A), D2.1 (VDD), H2.1, MD1.4 (VOUT), MD1.5 (SENSE), R2.2, R6.2
+12V: C1.1, D1.1 (K), J1.2, J2.2, MD1.2 (VIN), R1.1
DIN: H4.1, J3.2
DOUT: D2.2 (DOUT), J4.2
GND: C1.2, C2.2, D2.3 (VSS), H3.1, J1.1, J2.1, J3.1, J4.1, MD1.3 (GND), MD1.7 (GND), R5.2, R6.1, SW1.2 (B)
LED_Board: D2.4 (DIN), H1.1
unnamed: MD1.1 (ON/OFF), R1.2, SW1.1 (A)
unnamed: MD1.6 (TRIM), R3.1
unnamed: MD1.10 (PGOOD), R2.1
unnamed: R3.2, R4.2
unnamed: R4.1, R5.1

# Repository Tomoshibi-technology/Tomoshibi_Circuit (continued)

## KiCad design projects/RCJ_OnStage/Common_Control/Common_Control.kicad_pcb

Parts:
C1, C3, C4, C5, C11, C12, C15, C16, C18, C19, C20, C21, C22, C31, C32, C33, C34, C35: 0.1uF; C_0402_1005Metric
C2, C10: 10uF; C_0805_2012Metric
C6, C7, C24: 4.7uF; C_0603_1608Metric
C8, C13, C17, C25, C30: 1uF; C_0402_1005Metric
C9: 22uF; C_0805_2012Metric
C14, C23: ADJ_ST; C_Disc_D5.0mm_W2.5mm_P5.00mm
C26, C27, C28, C29: 470uF; C_Elec_8x10.2
D1: Yellow; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2, D3, D7, D8, D9, D10: D; D_SOD-123
D4: MA10EB045; DO-221BC
D5, D6, D12, D13, D14: Red; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D11, D15: D_Zener; D_SOD-323_HandSoldering
D16, D17, D18, D19: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12, H13: MountingHole_Pad; TestPoint_Pad_1.5x1.5mm
H14, H15, H16, H17: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x07_Female; PinSocket_1x07_P2.54mm_Horizontal
J2, J3, J4, J5: Conn_01x02_Female; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J6: USB_C_Receptacle_USB2.0; USB_C(simple)
J7: Conn_01x10_Female; IDC-Header_2x05_P2.54mm_Horizontal
J8, J9, J10, J11, J16, J17, J18, J19, J20, J21: Conn_01x03_Female; Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal
J22, J23: Conn_01x05_Female; Molex_SPOX_5268-05A_1x05_P2.50mm_Horizontal
JP1: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
LS1: Speaker; Buzzer_Murata_PKLCS1212E
MD1: OKL-T/6-W12N-C; MURATA_OKL-T-6-W12N-C; MOUSER_PART_NUMBER 580-OKL-T/6-W12N-C
Q1, Q4: Q_PMOS_GDS; TO-252-3_TabPin2
Q2, Q6: SSM6J808R
Q3, Q5, Q20, Q21, Q22, Q23: Q_NMOS_GSD; SOT-23
Q7, Q9, Q10, Q12, Q16, Q19, Q28, Q29: Q_PNP_BEC; SC-59_Handsoldering
Q8, Q11, Q13, Q14, Q15, Q17, Q18, Q24, Q25, Q26, Q27: Q_PMOS_GSD; SOT-23
R1, R2, R3, R4, R8, R9, R10, R11, R12, R14, R19, R22, R23, R29, R30, R31, R32, R33, R34, R35, R36, R38, R39, R40, R41, R42, R46, R47, R48, R49, R50, R51, R53, R54, R59, R60, R64, R65, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75: 10k; R_0402_1005Metric
R5, R6: 5.1k; R_0402_1005Metric
R7, R13, R15, R18, R20, R21, R25, R37, R43, R44, R45, R52, R55, R56, R57, R58, R63: 1k; R_0402_1005Metric
R16, R17: V_Divider; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R24: 100k; R_0402_1005Metric
R26: 330; R_0402_1005Metric
R27: 10; R_0402_1005Metric
R28: 1.2k; R_0402_1005Metric
R61, R62: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R76, R77: 7.5k; R_0603_1608Metric
R78, R79: 20k; R_0402_1005Metric
R80, R81, R82, R83: 2.2k; R_0402_1005Metric
R84: 120; R_0402_1005Metric
RV1: R_Potentiometer; TSR-3386K
SW1: SW_DPDT_x2; 6P_DPDT_ToggleSwitch
SW2, SW3, SW6, SW9, SW10, SW11, SW12: SW_SPST; SW_SPST_Omron_B3FS-100xP
SW4, SW14: SW_DIP_x02; DIP-4_W7.62mm
SW5: SW_DPDT_x2; SW_CuK_JS202011CQN_DPDT_Straight
SW7, SW8, SW15, SW16: SW_SPDT; 3P_SPDT_SlideSwitch
SW13: SW_DIP_x04; DIP-8_W7.62mm
TP1, TP3, TP4, TP5: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: CH340E; MSOP-10_3x3mm_P0.5mm
U2: TWE-L-WX; MonoWireless_TWE-L-WX
U3: 74LVC1G32; TSOT-23-5_HandSoldering
U4: AZ1084CD-3.3; TO-252-3_TabPin2
U5: STM32F446RETx; LQFP-64_10x10mm_P0.5mm
U6: NJU72501_Module; DIP-8_W7.62mm
U7: OLED_akitsuki; 128×64_OLED_White
U8, U9: MAX3485; SOP-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C8.2, C11.1, C12.1, C15.1, C16.1, C18.1, C20.1, C21.1, C22.1, C25.1, C29.1, C30.2, C31.1, C32.1, C33.1, D15.1 (K), J18.2, J19.2, Q17.2 (S), Q18.2 (S), Q19.2 (E), Q20.1 (G), Q21.1 (G), Q22.1 (G), Q23.1 (G), Q25.2 (S), Q27.2 (S), Q28.2 (E), Q29.2 (E), R1.1, R2.1, R54.2, R58.2, R61.1, R62.1, R64.2, R65.2, R66.2, R67.2, R72.2, R73.2, R74.2, R75.2, R80.1, R82.1, SW4.3, SW4.4, SW6.2 (B), SW7.2 (B), SW8.2 (B), SW9.2 (B), SW10.2 (B), SW11.2 (B), SW13.5, SW13.6, SW13.7, SW13.8, SW14.3, SW14.4, TP4.1, U2.5 (VCC), U5.1 (VBAT), U5.13 (VDDA), U5.19 (VDD), U5.32 (VDD), U5.48 (VDD), U5.64 (VDD), U6.1 (VIN), U7.2 (VCC), U8.8 (VCC), U9.8 (VCC)
+5V: C13.1, C28.1, D10.1 (K), D11.1 (K), J8.2, J9.2, J10.2, J11.2, Q8.2 (S), Q9.2 (E), Q11.2 (S), Q12.2 (E), Q14.2 (S), Q24.2 (S), Q26.2 (S), R39.2, R56.2, R68.2, R69.2, R70.2, R71.2, TP3.1, U3.5 (VCC), U4.3 (VI)
+7.5V: C26.1, C34.1, C35.1, D2.1 (K), D4.2 (A), J20.2, J21.2, Q4.2 (D), R16.1, TP1.1
/3.3VBUS: C5.1, J7.1, Q15.2 (S), R47.2
/3.3VSYS: C17.1, D10.2 (A), Q16.2 (E), Q17.3 (D), R40.2, R51.1, R52.2, U4.2 (VO)
/5VBAT: J4.2, J5.2, Q2.1 (D), Q2.2 (D), Q2.5 (D), Q2.6 (D)
/5VBUS_Switch: D8.2 (A), D9.2 (A), H9.1, R34.1, R37.2, U3.4
/5VSYS_1: C10.1, D7.2 (A), D8.1 (K), H7.1, MD1.4 (VOUT), MD1.5 (SENSE), Q10.2 (E), Q11.3 (D), R24.2, R28.2, U3.1
/5VSYS_2: D3.1 (K), D9.1 (K), H8.1, Q6.1 (D), Q6.2 (D), Q6.5 (D), Q6.6 (D), Q7.2 (E), Q8.3 (D), R18.1, U3.2
/5V_S-S: C7.1, Q2.4 (S), Q6.4 (S), R9.1, R11.1, SW1.5 (B)
/7.5VBAT: J2.2, J3.2, Q1.2 (D)
/7.5VCC: C9.1, C27.1, D4.1 (K), D7.1 (K), MD1.2 (VIN), R19.1
/7.5V_S-S: C6.1, Q1.3 (S), Q4.3 (S), R8.1, R10.1, SW1.2 (B)
BOOT0: H6.1, R41.1, SW11.1 (A), U5.60 (BOOT0)
DIP_SW1: R42.2, SW13.1, U5.41 (PA8)
DIP_SW2: R46.2, SW13.2, U5.44 (PA11)
DIP_SW3: R48.2, SW13.3, U5.45 (PA12)
DIP_SW4: R49.2, SW13.4, U5.50 (PA15)
F446USBRX: SW5.6 (C), U1.9 (RXD)
F446USBTX: SW5.3 (C), U1.8 (TXD)
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C8.1, C9.2, C10.2, C13.2, C14.1, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.1, C24.1, C25.2, C26.2, C27.2, C28.2, C29.2, C30.1, C31.2, C32.2, C33.2, C34.2, C35.2, D1.1 (K), D2.2 (A), D3.2 (A), D5.1 (K), D6.1 (K), D11.2 (A), D12.1 (K), D13.1 (K), D14.1 (K), D15.2 (A), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), J1.1, J2.1, J3.1, J4.1, J5.1, J6.A1 (GND), J6.S1 (SHIELD), J7.4, J8.1, J9.1, J10.1, J11.1, J16.1, J17.1, J18.1, J19.1, J20.1, J21.1, J22.1, J23.1, MD1.1 (ON/OFF), MD1.3 (GND), MD1.7 (GND), Q1.1 (G), Q2.3 (G), Q3.2 (S), Q5.2 (S), R3.2, R4.2, R5.1, R6.1, R8.2, R9.2, R12.1, R14.1, R17.2, R18.2, R19.2, R22.1, R23.1, R27.2, R28.1, R29.1, R30.1, R31.1, R32.1, R33.1, R35.2, R36.2, R37.1, R38.1, R39.1, R40.1, R41.2, R42.1, R46.1, R47.1, R48.1, R49.1, R50.1, R52.1, R53.1, R54.1, R59.1, R60.1, R78.2, R79.2, R81.2, R83.2, SW2.2 (B), SW3.2 (B), SW12.2 (B), SW15.2 (B), SW16.2 (B), TP5.1, U1.3 (GND), U2.20 (GND), U2.22 (ADC2/AI3), U2.23 (ADC1/AI1), U2.28 (GND), U2.30 (GND), U2.31 (GND), U2.32 (GND), U3.3 (GND), U4.1 (GND), U5.12 (VSSA), U5.18 (VSS), U5.28 (PB2), U5.31 (VSS), U5.47 (VSS), U5.63 (VSS), U6.2 (GND), U6.4 (GND), U7.1 (GND), U8.5 (GND), U9.5 (GND)
I2C1_SCL: R61.2, U5.61 (PB8), U7.3 (SCL)
I2C1_SDA: R62.2, U5.62 (PB9), U7.4 (SDA)
IND_3.3V: Q15.3 (D), Q18.3 (D), R57.2
IND_5V: Q13.3 (D), Q14.3 (D), R55.2
LED1: R43.2, U5.34 (PB13)
LED2: R44.2, U5.35 (PB14)
LED3: R45.2, U5.36 (PB15)
MainRX1_F446WriteTX: SW5.2 (B), U5.43 (PA10)
MainRX4_TweTX1: U2.14 (DIO14/SCL), U5.15 (PA1)
MainRX5_RS485TX: U5.54 (PD2), U8.1 (RO)
MainRX6_ArmTX: U5.38 (PC7), U9.1 (RO)
MainTX1_F446WriteRX: SW5.5 (B), U5.42 (PA9)
MainTX4_TweRX1: U2.17 (DIO15/SDA), U5.14 (PA0)
MainTX5_RS485RX: R76.2, U5.53 (PC12), U8.4 (DI)
MainTX6_ArmRX: R77.2, U5.37 (PC6), U9.4 (DI)
NRST: C19.1, H5.1, J7.6, SW12.1 (A), U5.7 (NRST)
NeoPixel1_H: J8.3, Q20.3 (D), R68.1
NeoPixel1_L: Q20.2 (S), R64.1, U5.22 (PA6)
NeoPixel2_H: J9.3, Q21.3 (D), R69.1
NeoPixel2_L: Q21.2 (S), R65.1, U5.21 (PA5)
NeoPixel3_H: J10.3, Q22.3 (D), R70.1
NeoPixel3_L: Q22.2 (S), R66.1, U5.39 (PC8)
NeoPixel4_H: J11.3, Q23.3 (D), R71.1
NeoPixel4_L: Q23.2 (S), R67.1, U5.40 (PC9)
unnamed: C4.1, U1.10 (V3)
unnamed: C6.2, Q4.1 (G), R10.2, R13.1
unnamed: C7.2, Q6.3 (G), R11.2, R15.1
unnamed: C14.2, Q13.1 (G), Q14.1 (G), R34.2
unnamed: C23.2, Q15.1 (G), Q18.1 (G), R51.2
unnamed: C24.2, U5.30 (VCAP_1)
unnamed: D1.2 (A), R7.1
unnamed: D5.2 (A), R20.1
unnamed: D6.2 (A), R21.1
unnamed: D12.2 (A), R43.1
unnamed: D13.2 (A), R44.1
unnamed: D14.2 (A), R45.1
unnamed: D16.2 (A), R55.1
unnamed: D17.2 (A), R56.1
unnamed: D18.2 (A), R57.1
unnamed: D19.2 (A), R58.1
unnamed: H2.1, U1.5 (~CTS)
unnamed: H3.1, U1.4 (~RTS)
unnamed: J6.A5 (CC1), R6.2
unnamed: J6.A6 (D+), U1.1 (UD+)
unnamed: J6.A7 (D-), U1.2 (UD-)
unnamed: J6.B5 (CC2), R5.2
unnamed: JP1.2 (B), R84.1
unnamed: LS1.1, R63.1, RV1.1, RV1.2
unnamed: LS1.2, R63.2, U6.7 (VO2)
unnamed: MD1.6 (TRIM), R25.1
unnamed: MD1.10 (PGOOD), R24.1
unnamed: Q3.3 (D), R13.2
unnamed: Q5.3 (D), R15.2
unnamed: Q7.1 (B), Q7.3 (C), Q9.1 (B), R22.2
unnamed: Q8.1 (G), Q9.3 (C), R23.2
unnamed: Q10.1 (B), Q10.3 (C), Q12.1 (B), R29.2
unnamed: Q11.1 (G), Q12.3 (C), R30.2
unnamed: Q16.1 (B), Q16.3 (C), Q19.1 (B), R50.2
unnamed: Q17.1 (G), Q19.3 (C), R53.2
unnamed: Q24.1 (G), R72.1, SW15.1 (A)
unnamed: Q25.1 (G), R73.1, SW15.3 (C)
unnamed: Q26.1 (G), R74.1, SW16.1 (A)
unnamed: Q27.1 (G), R75.1, SW16.3 (C)
unnamed: Q28.1 (B), R76.1
unnamed: Q28.3 (C), R78.1, U8.2 (~RE), U8.3 (DE)
unnamed: Q29.1 (B), R77.1
unnamed: Q29.3 (C), R79.1, U9.2 (~RE), U9.3 (DE)
unnamed: R7.2, U1.6 (TNOW)
unnamed: R25.2, R26.2
unnamed: R26.1, R27.1
unnamed: R59.2, SW14.1, U6.6 (EN1)
unnamed: R60.2, SW14.2, U6.5 (EN2)
unnamed: R82.2, R83.1, U9.7 (B)
unnamed: RV1.3, U6.8 (VO1)
PRG: H4.1, J1.3, R2.2, SW3.1 (A), U2.2 (DO1/PWM3)
RS485_A: J22.4, J23.4, JP1.1 (A), R80.2, U8.6 (A)
RS485_Arm: J20.3, J21.3, U9.6 (A)
RS485_B: J22.5, J23.5, R81.1, R84.2, U8.7 (B)
RST: C1.1, H1.1, J1.5, R1.2, SW2.1 (A), U2.21 (~RESET)
SET: J1.7, U2.13 (DIO12/DI1)
STLinkRX: J7.9, SW5.4 (A)
STLinkTX: J7.8, SW5.1 (A)
SWO: J7.7, U5.55 (PB3)
Sensor1: H10.1, J16.3, U5.8 (PC0)
Sensor1_Pw: J16.2, Q24.3 (D), Q25.3 (D)
Sensor2: H11.1, J17.3, U5.9 (PC1)
Sensor2_Pw: J17.2, Q26.3 (D), Q27.3 (D)
Sensor3: H12.1, J18.3, U5.10 (PC2)
Sensor4: H13.1, J19.3, U5.11 (PC3)
Slide_Switch1: R35.1, SW7.1 (A), U5.51 (PC10)
Slide_Switch2: R36.1, SW8.1 (A), U5.52 (PC11)
Speaker: U5.29 (PB10), U6.3 (DIN)
TCK: J7.3, U5.49 (PA14)
TMS: J7.5, U5.46 (PA13)
Tact_Switch1: C11.2, R31.2, SW6.1 (A), U5.57 (PB5)
Tact_Switch2: C12.2, R33.2, SW9.1 (A), U5.58 (PB6)
Tact_Switch3: C15.2, R38.2, SW10.1 (A), U5.59 (PB7)
TweWriteRX_TweTX0: J1.2, U2.8 (DIO6/TX)
TweWriteTX_TweRX0: J1.4, U2.9 (DIO7/RX)
Twe_LED1: R20.2, U2.11 (DIO9/DO4)
Twe_LED2: R21.2, U2.10 (DIO8/PWM4)
Twe_SW1: R12.2, SW4.1, U2.15 (DIO13/DI2)
Twe_SW2: R14.2, SW4.2, U2.18 (DIO16/DI4)
VBUS: C2.2, C3.1, J6.A4 (VBUS), Q13.2 (S), R32.2, U1.7 (VCC)
V_Measure: R16.2, R17.1, U5.27 (PB1)
主電源スイッチ_5V: Q5.1 (G), R4.1, SW1.4 (A)
主電源スイッチ_7.4V: Q3.1 (G), R3.1, SW1.1 (A)

Notes on the sheet:
BOOT0
TweLite
理想ダイオード/7.5Vライン
NRST
理想ダイオード/3.3VSYS
モニター
Speaker
OLED
主電源スイッチ
3.3V生成
センサー
タクトスイッチ
切替信号
DIPスイッチ
LED
NeoPixel
RS485
Conn to 7.5V
保護回路・スイッチ
電源切替/USB
パスコン
Conn to 5V
Capacitor
I/O
ねじ穴
TestPoint
4Pスイッチ
書き込み
5V生成
PowerModule
インジケーターLED
Conn
TweLiteR3
Conn to NeoPixel
理想ダイオード/5Vライン
スライドスイッチ
マイコン
Jumper
USB-C
F446RE

Board: 2 copper layers, 110.0 x 120.0 mm, 236 parts (21 on the bottom side), 128 nets.

## KiCad design projects/line_tracer/line_board/line_board.kicad_pcb

Parts:
D1, D2, D3: LED; LED_D3.0mm
J1: Conn_01x05_Female; JST_XH_S5B-XH-A_1x05_P2.50mm_Horizontal
Q1, Q2, Q3: Q_Photo_NPN_EC; LED_D3.0mm
R1, R2, R3: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4, R5, R6: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Connections:
+3.3V: J1.2, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1
GND: D1.1 (K), D2.1 (K), D3.1 (K), J1.1, Q1.1 (E), Q2.1 (E), Q3.1 (E)
unnamed: D1.2 (A), R4.2
unnamed: D2.2 (A), R5.2
unnamed: D3.2 (A), R6.2
sensor_output_0: J1.3, Q1.2 (C), R1.2
sensor_output_1: J1.4, Q2.2 (C), R2.2
sensor_output_2: J1.5, Q3.2 (C), R3.2

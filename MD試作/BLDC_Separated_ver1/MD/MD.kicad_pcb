# Repository Tomoshibi-technology/Tomoshibi_Circuit (continued)

## KiCad design Jun基板/人型ロボット基板/motordriver/motordriver.kicad_pcb

Parts:
C1: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3, C4, C7: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C11, C17: C_Polarized; CP_Radial_D5.0mm_P2.00mm
C6: C; CAPC3225X270N
C8, C14, C15, C16, C18, C20, C22, C24, C27, C28, C29, C31, C32, C33, C34: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9, C10, C12, C13, C21: C; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C19, C23, C30: 1uF_X5R_0603; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C25, C26: 20pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D6, D7, D10, D15, D16: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3, D4, D5, D8, D9, D11, D12, D13, D14: D; D_SOD-123
J1: USB_C_Receptacle_USB2.0; USB_C(simple)
J2: Conn_01x02_Female; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J3: Conn_01x05_Female; Molex_SPOX_5268-05A_1x05_P2.50mm_Horizontal
J4: Conn_01x10_Female; IDC-Header_2x05_P2.54mm_Horizontal
J5: Conn_01x06_Female; Molex_SPOX_5268-06A_1x06_P2.50mm_Horizontal
J6, J7, J8: Conn_01x03_Female; Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal
JP1: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
JP2, JP3: SolderJumper_3_Open; SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm_NumberLabels
MD1: OKL-T/6-W12N-C; MURATA_OKL-T-6-W12N-C; MOUSER_PART_NUMBER 580-OKL-T/6-W12N-C
Q1: Q_PNP_BEC; SC-59
Q2: Q_PMOS_GDS; TO-251-3_Vertical
Q3, Q4, Q5, Q6: Q_NMOS_GSD; SOT-23_Handsoldering
R1, R2, R3, R5, R22, R31, R39: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 7.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R13, R21, R23, R24, R25, R29, R30, R32, R34, R35, R36, R37, R40, R41, R42, R43, R48, R51, R52, R53, R56: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R9: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12, R26, R27, R44, R45: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15, R47: 510; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16, R19, R46, R54, R55: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R18: 10; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R20: 1.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R28, R33, R38: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R49, R50: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2, SW3, SW5, SW7: SW_SPDT; 3P_SPDT_SlideSwitch
SW4: SW_SPDT; 3P_SPDT_5Pin_ToggleSwitch
SW6, SW8: SW_SPST; SW_SPST_Omron_B3FS-100xP
U1: MAX3485; SOP-8_3.9x4.9mm_P1.27mm
U2: CH340E; MSOP-10_3x3mm_P0.5mm
U3, U16: TLP785; DIP-4_W7.62mm
U4, U15: IR2302; SOP-8_3.9x4.9mm_P1.27mm
U5, U6, U9, U10, U13: SSM6J808R; Mouser Part Number 757-SSM6K809RLXHF
U7, U8, U11, U12: TPH11006NL; Mouser Part Number 757-XPH6R30ANBL1XHQ
U14: AMS1117CD; TO-252-3_TabPin2
U17: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
Y1: Crystal; Crystal_HC18-U_Vertical

Connections:
+3.3V: C4.1, C22.2, C23.1, C28.2, C29.2, C30.1, C31.2, C32.2, C33.2, D13.2 (A), J4.2, J5.2, Q1.2 (E), Q3.1 (G), Q4.1 (G), Q5.1 (G), R9.2, R23.2, R24.2, R25.2, R48.2, R53.1, SW4.2 (B), SW5.2 (B), SW7.2 (B), U1.8 (VCC), U14.2 (VO), U17.1 (VDD), U17.5 (VDDA), U17.17 (VDD)
+5V: C17.1, C19.2, C20.1, D13.1 (K), R19.2, R37.2, R39.1, R40.2, R46.2, U6.4 (S), U9.4 (S), U10.4 (S), U14.3 (VI)
+7.5V: J2.2, Q2.2 (D)
BOOT0: J4.10, R56.1, SW7.1 (A), U17.31 (BOOT0)
CTS: U2.5 (~CTS)
Encoder_A: J5.3, U17.27 (PB4)
Encoder_B: J5.4, U17.28 (PB5)
GND: C1.1, C2.1, C3.1, C4.2, C5.2, C6.1, C7.1, C8.2, C9.1, C11.2, C12.2, C13.1, C14.1, C15.1, C16.1, C17.2, C18.1, C19.1, C20.2, C22.1, C23.2, C24.2, C25.1, C26.1, C27.2, C28.1, C29.1, C30.2, C31.1, C32.1, C33.1, C34.2, D1.1 (K), D2.1 (K), D3.2 (A), D6.1 (K), D7.1 (K), D9.2 (A), D10.1 (K), D12.2 (A), D15.1 (K), D16.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.1, J3.1, J4.4, J5.1, J6.1, J7.1, J8.1, MD1.3 (1_GROUND), MD1.7 (2_GROUND), Q2.1 (G), Q6.2 (S), R1.1, R2.1, R6.2, R7.2, R8.1, R12.2, R15.2, R18.1, R20.1, R21.2, R30.1, R34.1, R43.1, R47.2, R51.2, R52.2, R56.2, SW1.1 (A), SW2.2 (B), SW3.2 (B), SW6.1 (A), SW8.1 (A), U1.5 (GND), U2.3 (GND), U3.3, U4.4 (COM), U8.1 (S_1), U8.2 (S_2), U8.3 (S_3), U12.1 (S_1), U12.2 (S_2), U12.3 (S_3), U14.1 (ADJ), U15.4 (COM), U16.3, U17.16 (VSS), U17.32 (VSS)
LED_1: R54.2, U17.26 (PB3)
LED_2: R55.2, U17.15 (PB1)
MAX3485_MD_RX: U1.1 (RO), U17.30 (PB7)
MAX3485_MD_TX: R4.2, U1.4 (DI), U17.29 (PB6)
MD_GPIO: J3.3, U17.21 (PA11)
MD_Power: C14.2, J3.2, U13.1 (D_1), U13.2 (D_2), U13.5 (D_3), U13.6 (D_4)
Motor_A: C10.1, D8.2 (A), D9.1 (K), J5.5, R29.1, U4.6 (VS), U7.1 (S_1), U7.2 (S_2), U7.3 (S_3), U8.5 (D_1), U8.6 (D_2), U8.7 (D_3), U8.8 (D_4), U8.9 (D_5)
Motor_B: C21.1, D11.2 (A), D12.1 (K), J5.6, R42.1, U11.1 (S_1), U11.2 (S_2), U11.3 (S_3), U12.5 (D_1), U12.6 (D_2), U12.7 (D_3), U12.8 (D_4), U12.9 (D_5), U15.6 (VS)
NRST: C34.1, J4.6, R53.2, SW8.2 (B), U17.4 (NRST)
unnamed: C3.2, U2.10 (V3)
unnamed: C10.2, D5.1 (K), U4.8 (VB)
unnamed: C12.1, Q6.1 (G), R33.1
unnamed: C13.2, R28.2, U5.3 (G), U9.3 (G)
unnamed: C21.2, D14.1 (K), U15.8 (VB)
unnamed: C25.2, R49.2, Y1.1
unnamed: C26.2, R50.2, Y1.2
unnamed: D1.2 (A), R3.2
unnamed: D2.2 (A), R5.2
unnamed: D6.2 (A), R22.2
unnamed: D7.2 (A), R31.2
unnamed: D10.2 (A), R39.2
unnamed: D15.2 (A), R54.1
unnamed: D16.2 (A), R55.1
unnamed: J1.A5 (CC1), R2.2
unnamed: J1.A6 (D+), J1.B6 (D+), U2.1 (UD+)
unnamed: J1.A7 (D-), J1.B7 (D-), U2.2 (UD-)
unnamed: J1.B5 (CC2), R1.2
unnamed: JP1.2 (B), R10.2
unnamed: MD1.1 (~ON~{/OFF_CONTROL), R13.2, SW1.2 (B)
unnamed: MD1.6 (TRIM), R16.2
unnamed: Q1.1 (B), R4.1
unnamed: Q1.3 (C), R6.1, U1.2 (~RE), U1.3 (DE)
unnamed: Q6.3 (D), R38.1
unnamed: R5.1, U2.6 (TNOW)
unnamed: R15.1, U3.2
unnamed: R16.1, R17.2
unnamed: R17.1, R18.2
unnamed: R19.1, U3.4, U4.2 (IN)
unnamed: R26.1, U4.7 (HO)
unnamed: R26.2, R29.2, U7.4 (G)
unnamed: R27.1, U4.5 (LO)
unnamed: R27.2, R30.2, U8.4 (G)
unnamed: R31.1, U5.1 (D_1), U5.2 (D_2), U5.5 (D_3), U5.6 (D_4), U9.1 (D_1), U9.2 (D_2), U9.5 (D_3), U9.6 (D_4)
unnamed: R37.1, R38.2, U6.3 (G)
unnamed: R40.1, SW2.3 (C), U10.3 (G)
unnamed: R41.1, SW3.3 (C), U13.3 (G)
unnamed: R42.2, R44.2, U11.4 (G)
unnamed: R43.2, R45.2, U12.4 (G)
unnamed: R44.1, U15.7 (HO)
unnamed: R45.1, U15.5 (LO)
unnamed: R46.1, U15.2 (IN), U16.4
unnamed: R47.1, U16.2
unnamed: R49.1, U17.2 (PF0)
unnamed: R50.1, U17.3 (PF1)
PWM_A: U3.1, U17.19 (PA9)
PWM_B: U16.1, U17.20 (PA10)
RS485_MD_A: J3.4, JP1.1 (A), R9.1, U1.6 (A)
RS485_MD_B: J3.5, R8.2, R10.1, U1.7 (B)
RTS: U2.4 (~RTS)
STLK_UART2_RX: J4.8, JP2.3 (B)
STLK_UART2_TX: J4.9, JP3.3 (B)
SWO: J4.7
Slide_Switch_1: R52.1, SW5.1 (A), U17.13 (PA7)
TCK: J4.3, U17.24 (PA14)
TMS: J4.5, U17.23 (PA13)
Tact_Switch1: C27.1, R48.1, SW6.2 (B), U17.12 (PA6)
TapeLED_H_1: J7.3, Q3.3 (D), R32.1
TapeLED_H_2: J8.3, Q4.3 (D), R35.1
TapeLED_H_3: J6.3, Q5.3 (D), R36.1
TapeLED_L_1: Q3.2 (S), R23.1, U17.9 (PA3)
TapeLED_L_2: Q4.2 (S), R24.1, U17.10 (PA4)
TapeLED_L_3: Q5.2 (S), R25.1, U17.11 (PA5)
TapeLED_Power: C15.2, C16.2, C18.2, J6.2, J7.2, J8.2, R32.2, R35.2, R36.2, U10.1 (D_1), U10.2 (D_2), U10.5 (D_3), U10.6 (D_4)
Toggle_Switch_1: R51.1, SW4.1 (A), U17.18 (PA8)
USB-C_UART2_RX: JP2.1 (A), U2.8 (TXD)
USB-C_UART2_TX: JP3.1 (A), U2.9 (RXD)
VBUS: C1.2, C2.2, C7.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J4.1, R3.1, R21.1, R41.2, U2.7 (VCC), U5.4 (S), U13.4 (S)
VDD: C5.1, C6.2, C8.1, C11.1, C24.1, D3.1 (K), D4.1 (K), D5.2 (A), D8.1 (K), D11.1 (K), D14.2 (A), MD1.2 (VIN), Q2.3 (S), R7.1, R11.1, R13.1, U4.1 (VCC), U7.5 (D_1), U7.6 (D_2), U7.7 (D_3), U7.8 (D_4), U7.9 (D_5), U11.5 (D_1), U11.6 (D_2), U11.7 (D_3), U11.8 (D_4), U11.9 (D_5), U15.1 (VCC)
V_measure: R11.2, R12.1, U17.6 (PA0)
Write_UART2_RX: JP2.2 (C), U17.25 (PA15)
Write_UART2_TX: JP3.2 (C), U17.8 (PA2)
dcdcout: C9.2, D4.2 (A), MD1.4 (VOUT), MD1.5 (SENSE), R20.2, R22.1, R28.1, R33.2, R34.2, U6.1 (D_1), U6.2 (D_2), U6.5 (D_3), U6.6 (D_4)
shutdown: U4.3 (~SD), U15.3 (~SD), U17.22 (PA12)

Board: 2 copper layers, 95.0 x 72.0 mm, 149 parts (35 on the bottom side), 88 nets.

## KiCad design Jun基板/StepDown/StepDown.kicad_pcb

Parts:
C1: 22uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C2: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: D; D_SOD-123
D2: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
H1, H2, H3, H4: MountingHole_Pad; TestPoint_THTPad_D3.0mm_Drill1.5mm
J1, J2: Conn_01x02_Female; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J3, J4: Conn_01x02_Female; Molex_SPOX_5268-02A_1x02_P2.50mm_Horizontal
MD1: OKL-T/6-W12N-C; MURATA_OKL-T-6-W12N-C; MOUSER_PART_NUMBER 580-OKL-T/6-W12N-C
R1: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 10; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 1.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_SPDT; 3P_SPDT_SlideSwitch

Connections:
+5V: C2.1, D1.2 (A), D2.1 (VDD), H2.1, MD1.4 (VOUT), MD1.5 (SENSE), R2.2, R6.2
+12V: C1.1, D1.1 (K), J1.2, J2.2, MD1.2 (VIN), R1.1
DIN: H4.1, J3.2
DOUT: D2.2 (DOUT), J4.2
GND: C1.2, C2.2, D2.3 (VSS), H3.1, J1.1, J2.1, J3.1, J4.1, MD1.3 (GND), MD1.7 (GND), R5.2, R6.1, SW1.2 (B)
LED_Board: D2.4 (DIN), H1.1
unnamed: MD1.1 (ON/OFF), R1.2, SW1.1 (A)
unnamed: MD1.6 (TRIM), R3.1
unnamed: MD1.10 (PGOOD), R2.1
unnamed: R3.2, R4.2
unnamed: R4.1, R5.1

Notes on the sheet:
5V生成
Power Conn
Conn to Display
Board LED
Signal Conn

Board: 2 copper layers, 55.0 x 58.0 mm, 20 parts (0 on the bottom side), 11 nets.

## KiCad design Jun基板/Odometry/Odometry.kicad_pcb

Board: 2 copper layers, 72.0 x 47.0 mm, 79 parts (53 on the bottom side), 47 nets.

Parts:
3V3: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
BOOT0: SW_SPST; SW_SPST_Omron_B3FS-100xP
C2: 4.7uF; C_0603_1608Metric
C4, C14, C16, C18, C19: 0.1uF; C_0402_1005Metric
C6, C12: 470uF; C_Elec_8x10.2
C7: 10uF; C_0805_2012Metric
C10, C17: 1uF; C_0402_1005Metric
C13: ADJ_ST; C_Disc_D5.0mm_W2.5mm_P5.00mm
D2: D_Schottky; D_SOD-123
D6: D; D_SOD-123
IND: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J2: Conn_01x02_Female; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J3: Conn_01x10_Female; IDC-Header_2x05_P2.54mm_Horizontal
J4, J5, J6: Conn_01x05_Female; Molex_SPOX_5268-05A_1x05_P2.50mm_Horizontal
JP1: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
NRST: SW_SPST; SW_SPST_Omron_B3FS-100xP
PA0, PA5: SW_SPST; SW_SPST_Omron_B3FS-100xP
PA1, PA6: SW_SPDT; 3P_SPDT_SlideSwitch
PA7 PB0: SW_DIP_x02; DIP-4_W7.62mm
PA8, PA11: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
PB1: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
Q1, Q3: SSM6J808R
Q2: Q_NMOS_GSD; SOT-23
Q4, Q7, Q9: Q_PNP_BEC; SC-59_Handsoldering
Q5, Q6, Q8: Q_PMOS_GSD; SOT-23
R1, R2, R3, R4, R5, R6, R8, R12, R14, R15, R17, R19, R20, R21, R23, R24, R27: 10k; R_0402_1005Metric
R7, R9, R10, R11, R22, R28, R29, R30, R31: 1k; R_0402_1005Metric
R32: 7.5k; R_0603_1608Metric
R33: 20k; R_0402_1005Metric
R34, R35: 2.2k; R_0402_1005Metric
R36: 120; R_0402_1005Metric
SW5: SW_SPDT; 3P_SPDT_5Pin_ToggleSwitch
U1: BP5293-33; BP5293
U2: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
U3: MAX3485; SOP-8_3.9x4.9mm_P1.27mm
VBUS: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
VSYS: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder

Connections:
2PSW1: PA7 PB0.1, R12.2, U2.13 (PA7)
2PSW2: PA7 PB0.2, R14.2, U2.14 (PB0)
+3.3V: BOOT0.2 (B), C12.1, C14.1, C16.1, C17.1, C18.1, C19.1, J4.2, PA0.2 (B), PA1.2 (B), PA5.2 (B), PA6.2 (B), PA7 PB0.3, PA7 PB0.4, Q6.2 (S), Q7.2 (E), Q8.2 (S), Q9.2 (E), R24.2, R31.2, R34.1, U2.1 (VDD), U2.5 (VDDA), U2.17 (VDD), U3.8 (VCC)
+12V: J1.2, J2.2, Q1.1 (D), Q1.2 (D), Q1.5 (D), Q1.6 (D)
/S-S: C2.1, Q1.4 (S), Q3.4 (S), R2.1, R6.1, SW5.2 (B)
/VSYS: C10.1, D6.2 (A), Q4.2 (E), Q6.3 (D), R17.2, R21.1, R22.2, R28.2, U1.3 (VO)
BOOT0: BOOT0.1 (A), R27.1, U2.31 (BOOT0)
Encoder_OUT: J4.5, U2.9 (PA3)
GND: 3V3.1 (K), C4.2, C6.2, C7.2, C10.2, C12.2, C13.1, C14.2, C16.2, C17.2, C18.2, C19.2, IND.1 (K), J1.1, J2.1, J3.4, J4.1, J5.1, J6.1, NRST.2 (B), PA8.1 (K), PA11.1 (K), PB1.1 (K), Q1.3 (G), Q2.2 (S), R1.1, R2.2, R3.2, R4.2, R5.1, R8.2, R12.1, R14.1, R15.1, R17.1, R19.1, R20.1, R22.1, R23.1, R24.1, R27.2, R33.2, R35.2, U1.2 (GND), U2.16 (VSS), U2.32 (VSS), U3.5 (GND), VBUS.1 (K), VSYS.1 (K)
I2C1_SCL: J4.3, U2.29 (PB6)
I2C1_SDA: J4.4, U2.30 (PB7)
IndicatorLED: Q5.3 (D), Q8.3 (D), R30.2
LED1: R9.2, U2.15 (PB1)
LED2: R10.2, U2.18 (PA8)
LED3: R11.2, U2.21 (PA11)
MainRX1_MAX3485TX: U2.20 (PA10), U3.1 (RO)
MainRX2_STLinkTX: J3.8, U2.25 (PA15)
MainTX1_MAX3485RX: R32.2, U2.19 (PA9), U3.4 (DI)
MainTX2_STLinkRX: J3.9, U2.8 (PA2)
NRST: J3.6, NRST.1 (A), U2.4 (NRST)
unnamed: C2.2, Q3.3 (G), R6.2, R7.1
unnamed: C13.2, Q5.1 (G), Q8.1 (G), R21.2
unnamed: PB1.2 (A), R9.1
unnamed: PA8.2 (A), R10.1
unnamed: PA11.2 (A), R11.1
unnamed: R28.1, VSYS.2 (A)
unnamed: R29.1, VBUS.2 (A)
unnamed: IND.2 (A), R30.1
unnamed: 3V3.2 (A), R31.1
unnamed: JP1.2 (B), R36.1
unnamed: Q2.3 (D), R7.2
unnamed: Q4.1 (B), Q4.3 (C), Q7.1 (B), R20.2
unnamed: Q6.1 (G), Q7.3 (C), R23.2
unnamed: Q9.1 (B), R32.1
unnamed: Q9.3 (C), R33.1, U3.2 (~RE), U3.3 (DE)
RS485_MD_A: J5.4, J6.4, JP1.1 (A), R34.2, U3.6 (A)
RS485_MD_B: J5.5, J6.5, R35.1, R36.2, U3.7 (B)
Slide_Switch1: PA1.1 (A), R3.1, U2.7 (PA1)
Slide_Switch2: PA6.1 (A), R4.1, U2.12 (PA6)
TCK: J3.3, U2.24 (PA14)
TMS: J3.5, U2.23 (PA13)
Tact_Switch1: PA0.1 (A), R1.2, U2.6 (PA0)
Tact_Switch2: PA5.1 (A), R5.2, U2.11 (PA5)
VBUS: C4.1, J3.1, Q5.2 (S), R19.2, R29.2
VCC: C6.1, C7.1, D2.1 (K), D6.1 (K), R15.2, U1.1 (VI)
VDD: D2.2 (A), Q3.1 (D), Q3.2 (D), Q3.5 (D), Q3.6 (D)
主電源スイッチ: Q2.1 (G), R8.1, SW5.1 (A)

File Jun基板/Odometry/jlcpcb/production_files/BOM-Odometry.csv:

Comment,Designator,Footprint,LCSC
1k,"R10,R11,R22,R28,R29,R30,R31,R7,R9",R_0402_1005Metric,C11702
10uF,C7,C_0805_2012Metric,C15850
4.7uF,C2,C_0603_1608Metric,C19666
7.5k,R32,R_0603_1608Metric,C23234
120,R36,R_0402_1005Metric,C25079
10k,"R1,R12,R14,R15,R17,R19,R2,R20,R21,R23,R24,R27,R3,R4,R5,R6,R8",R_0402_1005Metric,C25744
20k,R33,R_0402_1005Metric,C25765
2.2k,"R34,R35",R_0402_1005Metric,C25879
0.1uF,"C14,C16,C18,C19,C4",C_0402_1005Metric,C307331
1uF,"C10,C17",C_0402_1005Metric,C52923
SW_SPDT,SW5,3P_SPDT_5Pin_ToggleSwitch,
Q_NMOS_GSD,Q2,SOT-23,
Q_PMOS_GSD,Q8,SOT-23,
D,D6,D_SOD-123,
Q_PNP_BEC,Q7,SC-59_Handsoldering,
Q_PMOS_GSD,Q5,SOT-23,
Q_PMOS_GSD,Q6,SOT-23,
470uF,C12,C_Elec_8x10.2,
ADJ_ST,C13,C_Disc_D5.0mm_W2.5mm_P5.00mm,
MAX3485,U3,SOP-8_3.9x4.9mm_P1.27mm,
Q_PNP_BEC,Q4,SC-59_Handsoldering,
Conn_01x05_Female,J5,Molex_SPOX_5268-05A_1x05_P2.50mm_Horizontal,
Jumper_2_Open,JP1,PinHeader_1x02_P2.54mm_Vertical,
D_Schottky,D2,D_SOD-123,
BP5293-33,U1,BP5293,
Conn_01x05_Female,J6,Molex_SPOX_5268-05A_1x05_P2.50mm_Horizontal,
470uF,C6,C_Elec_8x10.2,
Conn_01x02_Female,J1,AMASS_XT30PW-M_1x02_P2.50mm_Horizontal,
Conn_01x05_Female,J4,Molex_SPOX_5268-05A_1x05_P2.50mm_Horizontal,
SSM6J808R,Q1,SSM6J808R,
STM32F303K8Tx,U2,LQFP-32_7x7mm_P0.8mm,
SSM6J808R,Q3,SSM6J808R,
Conn_01x10_Female,J3,IDC-Header_2x05_P2.54mm_Horizontal,
Q_PNP_BEC,Q9,SC-59_Handsoldering,
Conn_01x02_Female,J2,AMASS_XT30PW-M_1x02_P2.50mm_Horizontal,
SW_SPST,BOOT0,SW_SPST_Omron_B3FS-100xP,
LED,PA8,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
LED,PB1,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
SW_SPST,PA0,SW_SPST_Omron_B3FS-100xP,
SW_SPST,PA5,SW_SPST_Omron_B3FS-100xP,
SW_SPDT,PA1,3P_SPDT_SlideSwitch,
LED,PA11,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
SW_SPDT,PA6,3P_SPDT_SlideSwitch,
Green,3V3,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,
SW_DIP_x02,PA7 PB0,DIP-4_W7.62mm,
